<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>bepi_colombo</value></param>
<param><key>author</key><value>Daniel Estevez</value></param>
<param><key>description</key><value>Decodes PCM/PM/Bi-phase 700kbaud data from BepiColombo</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>BepiColombo decoder</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alpha</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baudrate</value></param>
<param><key>value</key><value>700000</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>clk_bw</value></param>
<param><key>value</key><value>1e-2</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>codeword_len</value></param>
<param><key>value</key><value>17848</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), alpha, int(11*sps*nfilts))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2500000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>analog_pll_carriertracking_cc</key>
<param><key>id</key><value>analog_pll_carriertracking_cc_0</value></param>
<param><key>w</key><value>2*math.pi*100/samp_rate</value></param>
<param><key>max_freq</key><value>2*math.pi*10e3/samp_rate</value></param>
<param><key>min_freq</key><value>-2*math.pi*10e3/samp_rate</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/tmp/bepi_colombo_frames.u8</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/home/daniel/Descargas/bepicolombo-8420535000Hz_20200404_151554.wav</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_xx</key>
<param><key>id</key><value>digital_correlate_access_code_tag_xx_0</value></param>
<param><key>access_code</key><value>'0000001101000111011101101100011100100111001010001001010110110000'</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tagname</key><value>payload_start</value></param>
<param><key>threshold</key><value>12</value></param>
</block>
<block>
<key>digital_symbol_sync_xx</key>
<param><key>id</key><value>digital_symbol_sync_xx_0</value></param>
<param><key>damping</key><value>1.0</value></param>
<param><key>ted_gain</key><value>1.47</value></param>
<param><key>type</key><value>ff</value></param>
<param><key>resamp_type</key><value>digital.IR_MMSE_8TAP</value></param>
<param><key>loop_bw</key><value>clk_bw</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>ted_type</key><value>digital.TED_GARDNER</value></param>
</block>
<block>
<key>dslwp_ccsds_pseudo_randomizer</key>
<param><key>id</key><value>dslwp_ccsds_pseudo_randomizer_0</value></param>
<param><key>data_format</key><value>3</value></param>
</block>
<block>
<key>dslwp_ccsds_turbo_decode</key>
<param><key>id</key><value>dslwp_ccsds_turbo_decode_0</value></param>
<param><key>base</key><value>223</value></param>
<param><key>code_type</key><value>2</value></param>
<param><key>iterations</key><value>10</value></param>
<param><key>octets</key><value>5</value></param>
<param><key>sigma</key><value>0.7</value></param>
<param><key>update_sigma</key><value>0</value></param>
</block>
<block>
<key>dslwp_frame_spliter_f</key>
<param><key>id</key><value>dslwp_frame_spliter_f_0</value></param>
<param><key>frame_length</key><value>codeword_len</value></param>
<param><key>key</key><value>payload_start</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>[-0.1]*5 + [0.1]*5</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>label1</key><value>In-phase</value></param>
<param><key>label2</key><value>Quadrature</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-80</value></param>
<param><key>ymin</key><value>-115</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>style1</key><value>0</value></param>
<param><key>size</key><value>int(10e-3*baudrate)</value></param>
<param><key>srate</key><value>baudrate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>3</value></param>
<param><key>ymin</key><value>-3</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>interp</key><value>14</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<connection><source_block_id>analog_pll_carriertracking_cc_0</source_block_id><sink_block_id>blocks_complex_to_arg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pll_carriertracking_cc_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>analog_pll_carriertracking_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_xx_0</source_block_id><sink_block_id>dslwp_frame_spliter_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>digital_correlate_access_code_tag_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dslwp_ccsds_pseudo_randomizer_0</source_block_id><sink_block_id>dslwp_ccsds_turbo_decode_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>dslwp_ccsds_turbo_decode_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>dslwp_frame_spliter_f_0</source_block_id><sink_block_id>dslwp_ccsds_pseudo_randomizer_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>digital_symbol_sync_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
