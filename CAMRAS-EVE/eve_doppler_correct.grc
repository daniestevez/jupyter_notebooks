options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: eve_doppler_correct
    output_language: python
    run_options: run
    title: EVE Doppler correct
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: dwingeloo_doppler_corrected_5ksps.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: stockert_chan0_doppler_corrected_5ksps.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: stockert_chan1_doppler_corrected_5ksps.c64
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: dwingeloo_eve_full_2025_03_22_12_00_00_1299.500MHz_5ksps_ci16_le.sigmf-data
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: stockert_eve_full_2025_03_22_12_00_00_1299.500MHz_5ksps_ci16_le.chan0.sigmf-data
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: stockert_eve_full_2025_03_22_12_00_00_1299.500MHz_5ksps_ci16_le.chan1.sigmf-data
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: satellites_doppler_correction_0
  id: satellites_doppler_correction
  parameters:
    file: doppler_dwingeloo.txt
    samp_rate: samp_rate
    t0: '0'
  states: {}
- name: satellites_doppler_correction_0_0
  id: satellites_doppler_correction
  parameters:
    file: doppler_stockert.txt
    samp_rate: samp_rate
    t0: '0'
  states: {}
- name: satellites_doppler_correction_0_0_0
  id: satellites_doppler_correction
  parameters:
    file: doppler_stockert.txt
    samp_rate: samp_rate
    t0: '0'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_interleaved_short_to_complex_0_0_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', satellites_doppler_correction_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', satellites_doppler_correction_0_0, '0']
- [blocks_interleaved_short_to_complex_0_0_0, '0', satellites_doppler_correction_0_0_0, '0']
- [satellites_doppler_correction_0, '0', blocks_file_sink_0, '0']
- [satellites_doppler_correction_0_0, '0', blocks_file_sink_0_0, '0']
- [satellites_doppler_correction_0_0_0, '0', blocks_file_sink_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
