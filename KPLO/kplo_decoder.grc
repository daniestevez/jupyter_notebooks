options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: kplo_decoder
    output_language: python
    title: KPLO decoder
  states: {}

blocks:
- name: dec
  id: variable
  parameters:
    value: '2'
  states: {}
- name: dec_tc
  id: variable
  parameters:
    value: '50'
  states: {}
- name: dec_tlm
  id: variable
  parameters:
    value: '5'
  states: {}
- name: pll_bw
  id: variable
  parameters:
    value: '20'
  states: {}
- name: pll_limit
  id: variable
  parameters:
    value: 5e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: tlm_sps
  id: variable
  parameters:
    value: samp_rate/(tlm_symbol_rate * dec * dec_tlm)
  states: {}
- name: tlm_subcarrier
  id: variable
  parameters:
    value: 9 * tlm_symbol_rate
  states: {}
- name: tlm_symbol_rate
  id: variable
  parameters:
    value: 16.384e3
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: 2*np.pi*pll_limit*dec/samp_rate
    min_freq: '-2*np.pi*pll_limit*dec/samp_rate'
    w: 2*np.pi*pll_bw*dec/samp_rate
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: tlm_frames.u8
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: tc.c64
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/jupyter_notebooks/KPLO/camras-2022_08_05_08_44_13_2260.500MHz_1.0Msps_ci16_le.sigmf-data
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/jupyter_notebooks/KPLO/camras-2022_08_05_13_53_49_2260.500MHz_3.0Msps_ci16_le.sigmf-data
    repeat: 'False'
    type: short
  states: {state: disabled}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/jupyter_notebooks/KPLO/camras-2022_08_05_14_08_18_2260.830MHz_0.5Msps_ci16_le.sigmf-data
    repeat: 'False'
    type: short
  states: {state: disabled}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_interleaved_short_to_complex_0_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate/dec
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.01'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.01'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: tlm_sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1/int(tlm_sps)]*int(tlm_sps)'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 283.5e3
    decim: dec
    samp_rate: samp_rate
    taps: firdes.low_pass(1, 1, 0.45/dec, 0.1/dec)
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 283.5e3
    decim: dec*3
    samp_rate: samp_rate*3
    taps: firdes.low_pass(1, 1, 0.45/dec/3, 0.1/dec/3)
    type: ccf
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-46.5e3'
    decim: '1'
    samp_rate: samp_rate/2
    taps: '1'
    type: ccf
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tlm_subcarrier
    decim: dec_tlm
    samp_rate: samp_rate/dec
    taps: firdes.low_pass(1, samp_rate/dec, 45e3, 5e3)
    type: fcf
  states: {}
- name: freq_xlating_fir_filter_xxx_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 8e3
    decim: dec_tc
    samp_rate: samp_rate/dec
    taps: firdes.low_pass(1, 1, 0.45/dec_tc, 0.1/dec_tc)
    type: fcf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,1,1,1
    legend: 'False'
    name: Telemetry constellation
    size: int(tlm_symbol_rate/10)
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate/dec
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,0,1,1
    legend: 'False'
    name: Spectrum
    type: complex
    ymax: '-50'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate/dec
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,1,1,1
    label1: In-phase
    label2: Quadrature
    name: PLL output
    nconnections: '2'
    type: float
    ymax: '-50'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/(dec*dec_tlm)
    fc: '0'
    fftsize: '4096'
    gui_hint: 1,0,1,1
    legend: 'False'
    name: Telemetry subcarrier
    type: complex
    ymax: '-20'
    ymin: '-70'
  states: {}
- name: satellites_ccsds_concatenated_deframer_0
  id: satellites_ccsds_concatenated_deframer
  parameters:
    convolutional: '"CCSDS"'
    frame_size: '220'
    precoding: None
    rs_basis: '"dual"'
    rs_interleaving: '1'
    scrambler: '"CCSDS"'
    threshold: '4'
  states: {}
- name: satellites_ccsds_concatenated_deframer_0_0
  id: satellites_ccsds_concatenated_deframer
  parameters:
    convolutional: '"CCSDS"'
    frame_size: '220'
    precoding: None
    rs_basis: '"dual"'
    rs_interleaving: '1'
    scrambler: '"CCSDS"'
    threshold: '4'
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1.0'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: phase_modulation
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: phase_modulation
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: phase_modulation
  states: {}

connections:
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_float_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_freq_sink_x_0_0, '1']
- [blocks_complex_to_float_0, '1', virtual_sink_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_complex_to_real_0, '0', satellites_ccsds_concatenated_deframer_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_interleaved_short_to_complex_0_0_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_interleaved_short_to_complex_0_0_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [blocks_multiply_const_xx_0, '0', satellites_ccsds_concatenated_deframer_0_0, '0']
- [blocks_throttle_0, '0', analog_pll_carriertracking_cc_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [fir_filter_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_throttle_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_throttle_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', blocks_throttle_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', satellites_rms_agc_0, '0']
- [freq_xlating_fir_filter_xxx_1_0, '0', blocks_file_sink_1, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [satellites_ccsds_concatenated_deframer_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [satellites_ccsds_concatenated_deframer_0, out, satellites_hexdump_sink_0, in]
- [satellites_ccsds_concatenated_deframer_0_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [satellites_ccsds_concatenated_deframer_0_0, out, satellites_hexdump_sink_0, in]
- [satellites_rms_agc_0, '0', fir_filter_xxx_0, '0']
- [satellites_rms_agc_0, '0', qtgui_freq_sink_x_0_1, '0']
- [virtual_source_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [virtual_source_0_0, '0', freq_xlating_fir_filter_xxx_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
