<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lime_gnss_iot</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>1575.42e6</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>lowpass_taps</value></param>
<param><key>cutoff_freq</key><value>4700</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>500</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tstamp</value></param>
<param><key>value</key><value>'{}'.format(datetime.datetime.utcnow().isoformat())</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/tmp/gnss_fifo</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>file</key><value>'usb_modulation_iq_{}.c64'.format(datetime.datetime.utcnow().isoformat())</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>1.023e6/2</value></param>
<param><key>decim</key><value>200</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>lowpass_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import datetime</value></param>
</block>
<block>
<key>limesdr_rx_source</key>
<param><key>id</key><value>limesdr_rx_source_0</value></param>
<param><key>ant0</key><value>LNAL</value></param>
<param><key>bw0</key><value>0</value></param>
<param><key>dc_offset_mode0</key><value>0</value></param>
<param><key>corr0</key><value>0</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>iq_balance_mode0</key><value>0</value></param>
<param><key>lna_gain0</key><value>30</value></param>
<param><key>pga_gain0</key><value>0</value></param>
<param><key>tia_gain0</key><value>12</value></param>
<param><key>ant1</key><value></value></param>
<param><key>bw1</key><value>0</value></param>
<param><key>dc_offset_mode1</key><value>0</value></param>
<param><key>corr1</key><value>0</value></param>
<param><key>freq1</key><value>100e6</value></param>
<param><key>gain_mode1</key><value>False</value></param>
<param><key>iq_balance_mode1</key><value>0</value></param>
<param><key>lna_gain1</key><value>10</value></param>
<param><key>pga_gain1</key><value>20</value></param>
<param><key>tia_gain1</key><value>20</value></param>
<param><key>args</key><value></value></param>
<param><key>nchan</key><value>1</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>limesdr_rx_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>limesdr_rx_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
