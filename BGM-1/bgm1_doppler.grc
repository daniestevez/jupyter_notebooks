options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: bgm1_doppler
    output_language: python
    title: BMG-1 Doppler measurement
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '15625'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 4.2e3
  states: {}
- name: phase_downsample
  id: variable
  parameters:
    value: '5206'
  states: {}
- name: pll_bw
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '104166'
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: np.pi
    min_freq: '-np.pi'
    w: 2 * np.pi * pll_bw / samp_rate
  states: {}
- name: analog_pll_refout_cc_0_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: np.pi
    min_freq: '-np.pi'
    w: 2 * np.pi * pll_bw / samp_rate
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: baudrate / 2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: phase_upper.raw
    type: byte
    vlen: '12'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: phase_lower.raw
    type: byte
    vlen: '12'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: '2025-03-02_07-46-30_104166SPS_2251115000Hz.s16'
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: phase_downsample
    type: byte
    vlen: '12'
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: phase_downsample
    type: byte
    vlen: '12'
  states: {}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: '100'
    type: float
  states: {}
- name: blocks_keep_one_in_n_1_0
  id: blocks_keep_one_in_n
  parameters:
    n: '100'
    type: float
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-2 * np.pi * freq / samp_rate'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1000'
    srate: samp_rate / 100
    type: float
    ymax: np.pi
    ymin: '-np.pi'
  states: {}
- name: satellites_phase_unwrap_0
  id: satellites_phase_unwrap
  parameters: {}
  states: {}
- name: satellites_phase_unwrap_0_0
  id: satellites_phase_unwrap
  parameters: {}
  states: {}

connections:
- [analog_pll_refout_cc_0, '0', blocks_complex_to_arg_0, '0']
- [analog_pll_refout_cc_0_0, '0', blocks_complex_to_arg_0_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_1, '1']
- [blocks_complex_to_arg_0, '0', blocks_keep_one_in_n_1, '0']
- [blocks_complex_to_arg_0, '0', satellites_phase_unwrap_0, '0']
- [blocks_complex_to_arg_0_0, '0', blocks_keep_one_in_n_1_0, '0']
- [blocks_complex_to_arg_0_0, '0', satellites_phase_unwrap_0_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_file_sink_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_keep_one_in_n_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_keep_one_in_n_1_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_multiply_conjugate_cc_0, '0', analog_pll_refout_cc_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_xx_1, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_0, '1']
- [blocks_multiply_xx_1, '0', analog_pll_refout_cc_0_0, '0']
- [blocks_rotator_cc_0, '0', low_pass_filter_0, '0']
- [blocks_throttle2_0, '0', blocks_rotator_cc_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_0, '1']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [satellites_phase_unwrap_0, '0', blocks_keep_one_in_n_0, '0']
- [satellites_phase_unwrap_0_0, '0', blocks_keep_one_in_n_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
