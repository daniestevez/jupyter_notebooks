options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: bgm1_dwingeloo
    output_language: python
    title: BMG-1 GMSK decoder
  states: {}

blocks:
- name: C0
  id: variable
  parameters:
    value: S0[(L - 1) * round(pfb_arms * sps):] * np.prod([S0[(L - 1 -j) * round(pfb_arms * sps):-j*round(pfb_arms * sps)] for j in range(1,  L)], axis=0)
  states: {}
- name: L
  id: variable
  parameters:
    value: '4'
  states: {}
- name: S0
  id: variable
  parameters:
    value: np.concatenate((np.sin(phi), np.sin(np.pi/2 - phi)))
  states: {}
- name: access_code
  id: variable
  parameters:
    value: '''''.join([str(i) for i in (syncword+1)//2])'
  states: {}
- name: baudrate
  id: variable
  parameters:
    value: '15630'
  states: {}
- name: bt
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: dec
  id: variable
  parameters:
    value: '32'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '415880'
  states: {}
- name: gauss
  id: variable
  parameters:
    value: firdes.gaussian(1.0, sps * pfb_arms, bt, L * round(sps) * pfb_arms)
  states: {}
- name: pfb_arms
  id: variable
  parameters:
    value: '32'
  states: {}
- name: phi
  id: variable
  parameters:
    value: np.cumsum(pulse)/np.sum(pulse)*np.pi/2
  states: {}
- name: pulse
  id: variable
  parameters:
    value: np.convolve(gauss, np.ones(round(sps * pfb_arms)), mode='same')
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate / (baudrate * dec)
  states: {}
- name: syncword
  id: variable
  parameters:
    value: 2*np.unpackbits(np.frombuffer(bytes.fromhex(syncword_hex), dtype = 'uint8')).astype('int')-1
  states: {}
- name: syncword_hex
  id: variable
  parameters:
    value: '''1ACFFC1D'''
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_0_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: complex
  states: {}
- name: blocks_deinterleave_0_0
  id: blocks_deinterleave
  parameters:
    type: complex
  states: {}
- name: blocks_delay_2
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: bgm1_dwingeloo_frames.u8
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/contracting/BGM1/bgm1_2025_03_02_08_24_29_2250.700MHz_4.00Msps_ci16_le.sigmf-data
    repeat: 'False'
    type: short
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_interleave_1
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1j'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[1, -1j]'
  states: {}
- name: digital_costas_loop_cc_0_1
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.01'
  states: {}
- name: digital_symbol_sync_xx_0_1
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.01'
    nfilters: pfb_arms
    osps: '1'
    pfb_mf_taps: C0 * pfb_arms / np.sum(C0)
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_DANDREA_AND_MENGALI_GEN_MSK
    type: cc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq
    decim: dec
    samp_rate: samp_rate
    taps: firdes.low_pass(1, 1, 0.5/dec, 0.1/dec)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_1_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 0,1
    name: ''
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate / dec
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,0
    type: complex
    ymax: '-45'
    ymin: '-95'
  states: {}
- name: satellites_ccsds_concatenated_deframer_0
  id: satellites_ccsds_concatenated_deframer
  parameters:
    convolutional: '"CCSDS"'
    frame_size: 223 * 4
    precoding: None
    rs_basis: '"dual"'
    rs_interleaving: '4'
    scrambler: '"CCSDS"'
    threshold: '4'
  states: {}
- name: satellites_ccsds_concatenated_deframer_0_0
  id: satellites_ccsds_concatenated_deframer
  parameters:
    convolutional: '"CCSDS"'
    frame_size: 223 * 4
    precoding: None
    rs_basis: '"dual"'
    rs_interleaving: '4'
    scrambler: '"CCSDS"'
    threshold: '4'
  states: {}
- name: satellites_ccsds_concatenated_deframer_0_0_0
  id: satellites_ccsds_concatenated_deframer
  parameters:
    convolutional: '"CCSDS"'
    frame_size: 223 * 4
    precoding: None
    rs_basis: '"dual"'
    rs_interleaving: '4'
    scrambler: '"CCSDS"'
    threshold: '4'
  states: {}
- name: satellites_ccsds_concatenated_deframer_0_1
  id: satellites_ccsds_concatenated_deframer
  parameters:
    convolutional: '"CCSDS"'
    frame_size: 223 * 4
    precoding: None
    rs_basis: '"dual"'
    rs_interleaving: '4'
    scrambler: '"CCSDS"'
    threshold: '4'
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_rms_agc_1
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1.3'
  states: {}

connections:
- [blocks_complex_to_imag_0, '0', blocks_float_to_complex_1, '1']
- [blocks_complex_to_imag_0, '0', blocks_interleave_1, '1']
- [blocks_complex_to_imag_0_0, '0', blocks_interleave_0, '1']
- [blocks_complex_to_real_0, '0', blocks_float_to_complex_1, '0']
- [blocks_complex_to_real_0, '0', blocks_interleave_1, '0']
- [blocks_complex_to_real_0_0, '0', blocks_interleave_0, '0']
- [blocks_deinterleave_0, '0', blocks_complex_to_real_0, '0']
- [blocks_deinterleave_0, '1', blocks_complex_to_imag_0, '0']
- [blocks_deinterleave_0_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_deinterleave_0_0, '1', blocks_complex_to_imag_0_0, '0']
- [blocks_delay_2, '0', blocks_deinterleave_0_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_float_to_complex_1, '0', qtgui_const_sink_x_1_1, '0']
- [blocks_interleave_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_interleave_0, '0', satellites_ccsds_concatenated_deframer_0_0, '0']
- [blocks_interleave_1, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_interleave_1, '0', satellites_ccsds_concatenated_deframer_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', blocks_deinterleave_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_delay_2, '0']
- [blocks_multiply_const_vxx_1, '0', satellites_ccsds_concatenated_deframer_0_1, '0']
- [blocks_multiply_const_vxx_1_0, '0', satellites_ccsds_concatenated_deframer_0_0_0, '0']
- [blocks_multiply_xx_0, '0', digital_costas_loop_cc_0_1, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_vector_source_x_1, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [blocks_vector_source_x_1, '0', blocks_multiply_xx_0, '1']
- [digital_costas_loop_cc_0_1, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [digital_symbol_sync_xx_0_1, '0', blocks_multiply_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', satellites_rms_agc_1, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [satellites_ccsds_concatenated_deframer_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [satellites_ccsds_concatenated_deframer_0, out, satellites_hexdump_sink_0, in]
- [satellites_ccsds_concatenated_deframer_0_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [satellites_ccsds_concatenated_deframer_0_0, out, satellites_hexdump_sink_0, in]
- [satellites_ccsds_concatenated_deframer_0_0_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [satellites_ccsds_concatenated_deframer_0_0_0, out, satellites_hexdump_sink_0, in]
- [satellites_ccsds_concatenated_deframer_0_1, out, pdu_pdu_to_tagged_stream_0, pdus]
- [satellites_ccsds_concatenated_deframer_0_1, out, satellites_hexdump_sink_0, in]
- [satellites_rms_agc_1, '0', digital_symbol_sync_xx_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
