options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: bgm1_doppler_dwingeloo
    output_language: python
    title: BMG-1 Doppler measurement (Dwingeloo recording)
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '15625'
  states: {}
- name: dec
  id: variable
  parameters:
    value: '100'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '415880'
  states: {}
- name: phase_downsample
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: pll_bw
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: np.pi
    min_freq: '-np.pi'
    w: 2 * np.pi * pll_bw * dec / samp_rate
  states: {}
- name: analog_pll_refout_cc_0_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: np.pi
    min_freq: '-np.pi'
    w: 2 * np.pi * pll_bw * dec / samp_rate
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: baudrate / 2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate / dec
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: phase_upper_dwingeloo.raw
    type: byte
    vlen: '12'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: phase_lower_dwingeloo.raw
    type: byte
    vlen: '12'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: bgm1_2025_03_02_08_24_29_2250.700MHz_4.00Msps_ci16_le.sigmf-data
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: phase_downsample
    type: byte
    vlen: '12'
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: phase_downsample
    type: byte
    vlen: '12'
  states: {}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: '100'
    type: float
  states: {}
- name: blocks_keep_one_in_n_1_0
  id: blocks_keep_one_in_n
  parameters:
    n: '100'
    type: float
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq
    decim: dec
    samp_rate: samp_rate
    taps: firdes.low_pass(1, 1, 0.5/dec, 0.1/dec)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate / dec
    fc: '0'
    fftsize: '4096'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1000'
    srate: samp_rate / 100
    type: float
    ymax: np.pi
    ymin: '-np.pi'
  states: {}
- name: satellites_phase_unwrap_0
  id: satellites_phase_unwrap
  parameters: {}
  states: {}
- name: satellites_phase_unwrap_0_0
  id: satellites_phase_unwrap
  parameters: {}
  states: {}

connections:
- [analog_pll_refout_cc_0, '0', blocks_complex_to_arg_0, '0']
- [analog_pll_refout_cc_0_0, '0', blocks_complex_to_arg_0_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_1, '1']
- [blocks_complex_to_arg_0, '0', blocks_keep_one_in_n_1, '0']
- [blocks_complex_to_arg_0, '0', satellites_phase_unwrap_0, '0']
- [blocks_complex_to_arg_0_0, '0', blocks_keep_one_in_n_1_0, '0']
- [blocks_complex_to_arg_0_0, '0', satellites_phase_unwrap_0_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_file_sink_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_keep_one_in_n_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_keep_one_in_n_1_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_multiply_conjugate_cc_0, '0', analog_pll_refout_cc_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_xx_1, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_0, '1']
- [blocks_multiply_xx_1, '0', analog_pll_refout_cc_0_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_multiply_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_multiply_xx_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [satellites_phase_unwrap_0, '0', blocks_keep_one_in_n_0, '0']
- [satellites_phase_unwrap_0_0, '0', blocks_keep_one_in_n_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
