options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: voyager1_extract
    output_language: python
    title: Voyager-1 extract
  states: {}

blocks:
- name: carrier_freq
  id: variable
  parameters:
    value: '-291.5e3+140'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '35'
  states: {}
- name: decimation2
  id: variable
  parameters:
    value: '50'
  states: {}
- name: pll_bw_hz
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.9296875e6
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: np.pi
    min_freq: '-np.pi'
    w: 2*np.pi*pll_bw_hz*decimation/samp_rate
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/daniel/reu-2021/Voyager1_GBT/voyager1_sideband.c64
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/reu-2021/Voyager1_GBT/blc3_guppi_57386_VOYAGER1_0004.0000_only_vgr1_chan.ci8
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 22.5e3
    decim: decimation2
    samp_rate: samp_rate/decimation
    taps: firdes.low_pass(1.0, samp_rate/decimation, 350, 50)
    type: fcf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: carrier_freq
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 35e3, 5e3)
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate/decimation
    fc: '0'
    fftsize: '4096'
    nconnections: '2'
    type: float
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1.0'
  states: {}

connections:
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_float_0_0, '0']
- [blocks_complex_to_float_0_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_complex_to_float_0_0, '1', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_complex_to_float_0_0, '1', qtgui_freq_sink_x_1, '1']
- [blocks_file_source_0_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_throttle_0_0, '0']
- [blocks_throttle_0_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_file_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', satellites_rms_agc_0, '0']
- [satellites_rms_agc_0, '0', analog_pll_carriertracking_cc_0, '0']

metadata:
  file_format: 1
