options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: voyager1_decoder
    output_language: python
    title: Voyager-1 decoder
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '320'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    comment: |-
      -379.15e3 for recording 0011
      -379.15e3-475 for recording 0015
    value: '-379.15e3'
  states: {}
- name: cc_decoder_0
  id: variable_cc_decoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: cc_decoder_1
  id: variable_cc_decoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: cc_encoder_0
  id: variable_cc_encoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: '2'
    state_start: '0'
  states: {}
- name: cc_encoder_1
  id: variable_cc_encoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: '2'
    state_start: '0'
  states: {}
- name: decim_carrier
  id: variable
  parameters:
    value: round(samp_rate/decimation/10)
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '35'
  states: {}
- name: decimation2
  id: variable
  parameters:
    value: '50'
  states: {}
- name: nfilt
  id: variable
  parameters:
    value: '32'
  states: {}
- name: pll_bw_hz
  id: variable
  parameters:
    comment: |-
      2.5 for recording 0011
      5 for recording 0015
    value: '2.5'
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[-109, 79]'
  states: {}
- name: rrc_alpha
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilt, nfilt, 1.0/sps, rrc_alpha, int(11 * nfilt * sps))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.9296875e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/(baudrate*decimation*decimation2)*(1+117.9e-6)
  states: {}
- name: syncword
  id: variable
  parameters:
    value: 2*np.unpackbits(np.frombuffer(bytes.fromhex(syncword_hex), dtype = 'uint8')).astype('int')-1
  states: {}
- name: syncword_hex
  id: variable
  parameters:
    value: '''03915ED3'''
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: np.pi
    min_freq: '-np.pi'
    w: 2*np.pi*pll_bw_hz*decimation/samp_rate
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: viterbi_out_x2.u8
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /tmp/decim.c64
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: /tmp/sideband.f32
    type: float
  states: {}
- name: blocks_file_sink_1_1
  id: blocks_file_sink
  parameters:
    file: /tmp/symbols.c64
    type: complex
  states: {}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: symbols.f32
    type: float
  states: {}
- name: blocks_file_sink_3
  id: blocks_file_sink
  parameters:
    file: /tmp/carrier.c64
    type: complex
  states: {}
- name: blocks_file_sink_3_0
  id: blocks_file_sink
  parameters:
    file: /tmp/carrier_wide_power.f32
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/vgr1_blc23_guppi_59046_80036_DIAG_VOYAGER-1_0011.cs8
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: decim_carrier
    type: complex
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: decim_carrier
    type: float
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: byte
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*30
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.001'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.001'
    max_dev: '1e-3'
    nfilters: nfilt
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '0.5'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: cc_decoder_0
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: fec_extended_decoder_0_0
  id: fec_extended_decoder
  parameters:
    decoder_list: cc_decoder_1
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: syncword[::-1]/syncword.size
    type: fff
  states: {}
- name: fir_filter_xxx_1_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: syncword[::-1]/syncword.size
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '22497.347'
    decim: decimation2
    samp_rate: samp_rate/decimation
    taps: firdes.low_pass(1.0, samp_rate/decimation, 350, 50)
    type: fcf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: carrier_freq
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 35e3, 5e3)
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '4950'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/decimation
    type: fir_filter_ccf
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimation/decimation2
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate/decimation
    fc: '0'
    fftsize: '4096'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    nconnections: '2'
    size: '10000'
    srate: baudrate/2
    style1: '0'
    tr_chan: '1'
    tr_delay: '1e-4'
    tr_level: '-0.8'
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    nconnections: '2'
    size: '10000'
    srate: baudrate/2
    style1: '0'
    tr_chan: '1'
    tr_delay: '1e-4'
    tr_level: '-0.8'
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-3'
    reference: '1.0'
  states: {}
- name: satellites_rms_agc_1
  id: satellites_rms_agc
  parameters:
    alpha: '1e-3'
    reference: '1.2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: data_sideband
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: symbols
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: residual_carrier
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: data_sideband
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: symbols
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: residual_carrier
  states: {}

connections:
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_float_0, '0']
- [analog_pll_carriertracking_cc_0, '0', virtual_sink_2, '0']
- [blocks_add_const_vxx_0, '0', fir_filter_xxx_1, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_const_vxx_0_0, '0', fir_filter_xxx_1_0, '0']
- [blocks_add_const_vxx_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_complex_to_float_0, '1', blocks_file_sink_1_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_freq_sink_x_1, '1']
- [blocks_complex_to_float_0, '1', virtual_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_complex_to_real_0, '0', virtual_sink_1, '0']
- [blocks_conjugate_cc_0, '0', blocks_throttle_0, '0']
- [blocks_delay_0, '0', fec_extended_decoder_0_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_integrate_xx_0, '0', blocks_file_sink_3, '0']
- [blocks_integrate_xx_0_0, '0', blocks_file_sink_3_0, '0']
- [blocks_interleave_0, '0', blocks_file_sink_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_file_sink_1_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [fec_extended_decoder_0, '0', blocks_char_to_float_0, '0']
- [fec_extended_decoder_0, '0', blocks_interleave_0, '0']
- [fec_extended_decoder_0_0, '0', blocks_char_to_float_0_0, '0']
- [fec_extended_decoder_0_0, '0', blocks_interleave_0, '1']
- [fir_filter_xxx_1, '0', qtgui_time_sink_x_0, '1']
- [fir_filter_xxx_1_0, '0', qtgui_time_sink_x_0_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', satellites_rms_agc_1, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_file_sink_1, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', satellites_rms_agc_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [low_pass_filter_0, '0', blocks_integrate_xx_0, '0']
- [satellites_rms_agc_0, '0', analog_pll_carriertracking_cc_0, '0']
- [satellites_rms_agc_1, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [virtual_source_0_0, '0', blocks_delay_0, '0']
- [virtual_source_0_0, '0', blocks_file_sink_2, '0']
- [virtual_source_0_0, '0', fec_extended_decoder_0, '0']
- [virtual_source_1, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
