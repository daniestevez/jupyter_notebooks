options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: voyager1_viterbi
    output_language: python
    run_options: run
    title: Voyager-1 Viterbi
  states: {}

blocks:
- name: cc_decoder
  id: variable_cc_decoder_def
  parameters:
    framebits: '64'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: cc_encoder
  id: variable_cc_encoder_def
  parameters:
    framebits: '64'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: '2'
    state_start: '0'
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[-109, 79]'
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: convolutional_encoder_out.u8
    type: byte
  states: {}
- name: blocks_file_sink_1_1
  id: blocks_file_sink
  parameters:
    file: viterbi_decoder_out.u8
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: voyager1_symbols.f32
    repeat: 'False'
    type: float
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: cc_decoder
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: cc_encoder
    puncpat: '''11'''
    threadtype: none
  states: {}

connections:
- [blocks_file_source_0, '0', fec_extended_decoder_0, '0']
- [fec_extended_decoder_0, '0', blocks_file_sink_1_1, '0']
- [fec_extended_decoder_0, '0', fec_extended_encoder_0, '0']
- [fec_extended_encoder_0, '0', blocks_file_sink_1, '0']

metadata:
  file_format: 1
