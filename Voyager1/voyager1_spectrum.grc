options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: voyager1_spectrum
    output_language: python
    run_options: run
    title: Voyager-1 spectrum
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '30'
  states: {}
- name: nfft
  id: variable
  parameters:
    value: 2**20
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: outfile
    type: float
    vlen: nfft
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: infile
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: decim
    type: float
    vlen: nfft
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    nthreads: '16'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: infile
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}
- name: outfile
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_integrate_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
