options:
  parameters:
    author: Daniel Estevez
    description: Demodulates 100 baud BPSK telemetry from LES-9
    generate_options: qt_gui
    id: les9
    output_language: python
    title: LES-9 decoder
  states: {}

blocks:
- name: clk_bw
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,0,1,1
    type: real
    value: '1e-3'
  states: {}
- name: loop_bw
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,1,1,1
    type: real
    value: '0.2'
  states: {}
- name: lowpass_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '1500'
    gain: '1.0'
    samp_rate: samp_rate
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/symbols_les9.f32
    type: float
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/gqrx_20200113_052915_10700000_32000_fc.raw
    repeat: 'True'
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: loop_bw
  states: {}
- name: digital_symbol_sync_xx_1
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: loop_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: 640/100
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1.0/6.0]*6'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '1836'
    decim: '10'
    samp_rate: samp_rate
    taps: lowpass_taps
    type: ccf
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '120'
    decim: '5'
    gain: '1'
    samp_rate: samp_rate/10
    type: fir_filter_ccf
    width: '20'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 0,1,1,1
    size: '1024'
    type: complex
    xmax: '4'
    xmin: '-4'
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate/50
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,0,1,1
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-27'
    ymin: '-50'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,2
    marker1: '0'
    size: '10000'
    srate: '100'
    style1: '0'
    type: float
    ymax: '4'
    ymin: '-4'
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-4'
    reference: '1.0'
  states: {}

connections:
- [blocks_complex_to_real_0, '0', blocks_file_sink_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_file_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_1, '0', digital_costas_loop_cc_0, '0']
- [fir_filter_xxx_0, '0', digital_symbol_sync_xx_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', satellites_rms_agc_0, '0']
- [satellites_rms_agc_0, '0', fir_filter_xxx_0, '0']
- [satellites_rms_agc_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
