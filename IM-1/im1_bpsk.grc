options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: im1_bpsk
    output_language: python
    title: IM-1 BPSK decoder
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '''''.join([str(i) for i in (syncword+1)//2])'
  states: {}
- name: baudrate
  id: variable
  parameters:
    value: '2511.5'
  states: {}
- name: dec
  id: variable
  parameters:
    value: '6'
  states: {}
- name: pll_bw
  id: variable
  parameters:
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '144000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate / (dec * baudrate)
  states: {}
- name: syncword
  id: variable
  parameters:
    value: 2*np.unpackbits(np.frombuffer(bytes.fromhex(syncword_hex), dtype = 'uint8')).astype('int')-1
  states: {}
- name: syncword_hex
  id: variable
  parameters:
    value: '''1ACFFC1D'''
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: im1_bpsk_frames.u8
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: '2024-02-22_20-10-59_144000SPS_2210600000Hz.s16'
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_not_xx_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_not_xx_0_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.1'
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    discard_crc: 'True'
    final_xor: '0x0'
    initial_value: '0xFFFF'
    input_reflected: 'False'
    num_bits: '16'
    poly: '0x1021'
    result_reflected: 'False'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '128'
    rolloff: '1'
    samps_per_sym: sps
    type: cc
    w: '0.01'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.01'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1/int(0.5*sps)] * int(0.5*sps)'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-6.8e3'
    decim: dec
    samp_rate: samp_rate
    taps: firdes.low_pass(1, 1, 0.5/dec, 0.1/dec)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 0,1,1,1
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / dec
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,0,1,1
    label1: FLL output
    label2: Original signal
    name: Spectrum
    nconnections: '2'
    type: complex
    ymax: '-20'
    ymin: '-80'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,2
    name: FLL output (time domain)
    size: '1024'
    srate: samp_rate / dec
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: satellites_ccsds_descrambler_0
  id: satellites_ccsds_descrambler
  parameters: {}
  states: {}
- name: satellites_ccsds_viterbi_0
  id: satellites_ccsds_viterbi
  parameters: {}
  states: {}
- name: satellites_ccsds_viterbi_0_0
  id: satellites_ccsds_viterbi
  parameters: {}
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '0.8'
  states: {}
- name: satellites_rms_agc_0_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-3'
    reference: '1'
  states: {}
- name: satellites_sync_to_pdu_0_0
  id: satellites_sync_to_pdu
  parameters:
    packlen: 153 * 8
    sync: '"00011010110011111111110000011101"'
    threshold: '0'
  states: {}
- name: satellites_sync_to_pdu_0_1
  id: satellites_sync_to_pdu
  parameters:
    packlen: 153 * 8
    sync: '"00011010110011111111110000011101"'
    threshold: '0'
  states: {}
- name: satellites_sync_to_pdu_0_2
  id: satellites_sync_to_pdu
  parameters:
    packlen: 153 * 8
    sync: '"00011010110011111111110000011101"'
    threshold: '0'
  states: {}
- name: satellites_sync_to_pdu_0_3
  id: satellites_sync_to_pdu
  parameters:
    packlen: 153 * 8
    sync: '"00011010110011111111110000011101"'
    threshold: '0'
  states: {}

connections:
- [blocks_complex_to_real_0, '0', blocks_delay_0, '0']
- [blocks_complex_to_real_0, '0', satellites_ccsds_viterbi_0, '0']
- [blocks_delay_0, '0', satellites_ccsds_viterbi_0_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_not_xx_0, '0', satellites_sync_to_pdu_0_1, '0']
- [blocks_not_xx_0_0, '0', satellites_sync_to_pdu_0_3, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_crc_check_0, ok, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_fll_band_edge_cc_0, '0', fir_filter_xxx_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_1, '0']
- [fir_filter_xxx_0, '0', satellites_rms_agc_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', satellites_rms_agc_0_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0_0, '0']
- [satellites_ccsds_descrambler_0, out, digital_crc_check_0, in]
- [satellites_ccsds_viterbi_0, '0', blocks_not_xx_0, '0']
- [satellites_ccsds_viterbi_0, '0', satellites_sync_to_pdu_0_0, '0']
- [satellites_ccsds_viterbi_0_0, '0', blocks_not_xx_0_0, '0']
- [satellites_ccsds_viterbi_0_0, '0', satellites_sync_to_pdu_0_2, '0']
- [satellites_rms_agc_0, '0', digital_symbol_sync_xx_0, '0']
- [satellites_rms_agc_0_0, '0', digital_fll_band_edge_cc_0, '0']
- [satellites_rms_agc_0_0, '0', qtgui_freq_sink_x_0, '1']
- [satellites_sync_to_pdu_0_0, out, satellites_ccsds_descrambler_0, in]
- [satellites_sync_to_pdu_0_1, out, satellites_ccsds_descrambler_0, in]
- [satellites_sync_to_pdu_0_2, out, satellites_ccsds_descrambler_0, in]
- [satellites_sync_to_pdu_0_3, out, satellites_ccsds_descrambler_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
