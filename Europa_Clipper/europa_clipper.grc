options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: europa_clipper
    output_language: python
    title: Europa Clipper decoder
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '''''.join([str(i) for i in (syncword+1)//2])[-64:]'
  states: {}
- name: baudrate
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 10.22e3
  states: {}
- name: pll_bw
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate / baudrate
  states: {}
- name: syncword
  id: variable
  parameters:
    value: 2*np.unpackbits(np.frombuffer(bytes.fromhex(syncword_hex), dtype = 'uint8')).astype('int')-1
  states: {}
- name: syncword_hex
  id: variable
  parameters:
    value: '''25D5C0CE8990F6C9461BF79CDA2A3F31766F0936B9E40863'''
  states: {}
- name: syncword_threshold
  id: variable
  parameters:
    value: '12'
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: np.pi
    min_freq: '-np.pi'
    w: 2 * np.pi * pll_bw / samp_rate
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: europa_clipper_frames.u8
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: Europa_Clipper_2024-10-14T17_33_12_x.sigmf-data
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: Europa_Clipper_2024-10-14T17_33_12_y.sigmf-data
    repeat: 'False'
    type: short
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-2 * np.pi * freq / samp_rate'
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-2 * np.pi * freq / samp_rate'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate * 10
    type: complex
  states: {state: bypassed}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.01'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: dslwp_ccsds_pseudo_randomizer_0
  id: dslwp_ccsds_pseudo_randomizer
  parameters:
    data_format: '3'
  states: {}
- name: dslwp_ccsds_turbo_decode_0
  id: dslwp_ccsds_turbo_decode
  parameters:
    base: '223'
    code_type: '6'
    iterations: '10'
    octets: '5'
    sigma: '0.5'
    update_sigma: '1'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1/round(sps)] * round(sps)'
    type: fff
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: syncword[::-1]/syncword.size
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,1,1,1
    label1: In-phase
    label2: Quadrature
    name: PLL output
    nconnections: '2'
    type: float
    ymax: '30'
    ymin: '-40'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,0,1,1
    label1: Signal polarization
    label2: Orthogonal polarization
    name: Auto-polarization
    nconnections: '2'
    type: complex
    ymax: '30'
    ymin: '-40'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,2
    label1: Symbols
    label2: ASM correlation
    marker1: '0'
    nconnections: '2'
    size: (53544+192)*3
    srate: baudrate
    style1: '0'
    tr_chan: '1'
    tr_delay: '1e-4'
    tr_level: '-0.8'
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}
- name: satellites_autopolarization_0
  id: satellites_autopolarization
  parameters:
    fft_avg: round(0.1 * samp_rate / 2048)
    fft_size: '2048'
    iir_weight: '0.1'
  states: {}
- name: satellites_crc_check_0
  id: satellites_crc_check
  parameters:
    discard_crc: 'True'
    final_xor: '0x0'
    initial_value: '0xFFFF'
    input_reflected: 'False'
    num_bits: '16'
    poly: '0x1021'
    result_reflected: 'False'
  states: {}
- name: satellites_doppler_correction_0
  id: satellites_doppler_correction
  parameters:
    file: europa_clipper_doppler.txt
    samp_rate: samp_rate
    t0: '1728927204.1341120564778646'
  states: {}
- name: satellites_doppler_correction_0_0
  id: satellites_doppler_correction
  parameters:
    file: europa_clipper_doppler.txt
    samp_rate: samp_rate
    t0: '1728927204.1341120564778646'
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-3'
    reference: '1.0'
  states: {}
- name: satellites_sync_to_pdu_soft_0
  id: satellites_sync_to_pdu_soft
  parameters:
    packlen: '53544'
    sync: access_code
    threshold: syncword_threshold
  states: {}

connections:
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_float_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', blocks_float_to_complex_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_freq_sink_x_0, '1']
- [blocks_complex_to_real_1, '0', fir_filter_xxx_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0_0, '0']
- [blocks_float_to_complex_0, '0', satellites_rms_agc_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', satellites_doppler_correction_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', satellites_doppler_correction_0_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_rotator_cc_0, '0', satellites_autopolarization_0, '0']
- [blocks_rotator_cc_0_0, '0', satellites_autopolarization_0, '1']
- [blocks_throttle2_0, '0', analog_pll_carriertracking_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', fir_filter_xxx_1, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', satellites_sync_to_pdu_soft_0, '0']
- [dslwp_ccsds_pseudo_randomizer_0, out, dslwp_ccsds_turbo_decode_0, in]
- [dslwp_ccsds_turbo_decode_0, out, satellites_crc_check_0, in]
- [fir_filter_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [fir_filter_xxx_1, '0', qtgui_time_sink_x_0, '1']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [satellites_autopolarization_0, '0', blocks_throttle2_0, '0']
- [satellites_autopolarization_0, '0', qtgui_freq_sink_x_0_0, '0']
- [satellites_autopolarization_0, '1', qtgui_freq_sink_x_0_0, '1']
- [satellites_crc_check_0, ok, pdu_pdu_to_tagged_stream_0, pdus]
- [satellites_crc_check_0, ok, satellites_hexdump_sink_0, in]
- [satellites_doppler_correction_0, '0', blocks_rotator_cc_0, '0']
- [satellites_doppler_correction_0_0, '0', blocks_rotator_cc_0_0, '0']
- [satellites_rms_agc_0, '0', blocks_complex_to_real_1, '0']
- [satellites_sync_to_pdu_soft_0, out, dslwp_ccsds_pseudo_randomizer_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
