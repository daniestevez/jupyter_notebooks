options:
  parameters:
    author: daniel
    generate_options: no_gui
    id: meridian_pwr
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: T
  id: variable
  parameters:
    value: '100e-6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: meridian_pwr.f32
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/Descargas/gqrx_20210117_223857_994299999_2000000_fc.raw
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: int(samp_rate * T)
    type: float
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_file_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_integrate_xx_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
