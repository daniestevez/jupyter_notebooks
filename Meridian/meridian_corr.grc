options:
  parameters:
    author: daniel
    generate_options: qt_gui
    id: meridian_corr
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: 1.2e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: '-91473.4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2000000*4
  states: {}
- name: sequence
  id: variable
  parameters:
    value: 2*np.array([int(a) for a in sequence_str])-1
  states: {}
- name: sequence_str
  id: variable
  parameters:
    value: '''000011001011001001000010100101001000111101001011110010011001000001111111101100000010101101000101101011111001000110010111110011101111111011110001100010011001100110001100101001011011100010100111101000011110011101001111001100000000011010111111001101101010111'''
  states: {}
- name: waveform
  id: variable
  parameters:
    value: sequence[np.int32(np.arange(0, sequence.size, baudrate/samp_rate))]
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: 2e6
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: meridian_corr_sparse.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: meridian_corr_sparse_pos.i32
    type: int
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/Descargas/gqrx_20210117_223857_994299999_2000000_fc.raw
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, threshold=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Sparser',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64, np.int32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.threshold = threshold
              self.offset = 0
              #self.set_auto_consume(False)

          def general_work(self, input_items, output_items):
              """example: multiply with constant"""
              inp = input_items[0][:output_items[0].size]
              select = np.where(np.abs(inp) >= self.threshold)[0]
              output_items[0][:select.size] = inp[select]
              output_items[1][:select.size] = self.offset + select
              self.offset += inp.size
              self.consume_each(inp.size)
              return select.size
    threshold: '4.5'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: waveform[::-1]
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1000000'
    srate: samp_rate
    type: complex
    ymax: '20'
    ymin: '-20'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_file_source_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', rational_resampler_xxx_0, '0']
- [epy_block_0, '0', blocks_file_sink_0, '0']
- [epy_block_0, '1', blocks_file_sink_0_0, '0']
- [fir_filter_xxx_0, '0', epy_block_0, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', fir_filter_xxx_0, '0']

metadata:
  file_format: 1
