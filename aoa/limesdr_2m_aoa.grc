<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>limesdr_2m_aoa</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>aprs_taps</value></param>
<param><key>cutoff_freq</key><value>12e3</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filename</value></param>
<param><key>value</key><value>'/home/daniel/aoa_graves_{}.2xc64'.format(tstamp)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filename_aprs</value></param>
<param><key>value</key><value>'/home/daniel/aoa_aprs_{}.2xc64'.format(tstamp)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filename_sat</value></param>
<param><key>value</key><value>'/home/daniel/aoa_sat_{}.2xc64'.format(tstamp)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>145e6</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>graves_taps</value></param>
<param><key>cutoff_freq</key><value>2e3</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>500</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>5000000</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>sat_taps</value></param>
<param><key>cutoff_freq</key><value>100e3</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>10e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tstamp</value></param>
<param><key>value</key><value>'{}'.format(datetime.datetime.utcnow().isoformat())</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>filename</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0</value></param>
<param><key>file</key><value>filename_sat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0</value></param>
<param><key>file</key><value>filename_aprs</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0_0_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>143.05e6 - freq</value></param>
<param><key>decim</key><value>1000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>graves_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0</value></param>
<param><key>center_freq</key><value>143.05e6 - freq</value></param>
<param><key>decim</key><value>1000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>graves_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_1</value></param>
<param><key>center_freq</key><value>145.9e6 - freq</value></param>
<param><key>decim</key><value>20</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>sat_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_1_0</value></param>
<param><key>center_freq</key><value>145.9e6 - freq</value></param>
<param><key>decim</key><value>20</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>sat_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_1_1</value></param>
<param><key>center_freq</key><value>144.8e6 - freq</value></param>
<param><key>decim</key><value>200</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>aprs_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_1_1_0</value></param>
<param><key>center_freq</key><value>144.8e6 - freq</value></param>
<param><key>decim</key><value>200</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>aprs_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import datetime</value></param>
</block>
<block>
<key>limesdr_rx_source</key>
<param><key>id</key><value>limesdr_rx_source_0</value></param>
<param><key>ant0</key><value>LNAL</value></param>
<param><key>bw0</key><value>0</value></param>
<param><key>dc_offset_mode0</key><value>0</value></param>
<param><key>corr0</key><value>0</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>iq_balance_mode0</key><value>0</value></param>
<param><key>lna_gain0</key><value>30</value></param>
<param><key>pga_gain0</key><value>0</value></param>
<param><key>tia_gain0</key><value>12</value></param>
<param><key>ant1</key><value>LNAL</value></param>
<param><key>bw1</key><value>0</value></param>
<param><key>dc_offset_mode1</key><value>0</value></param>
<param><key>corr1</key><value>0</value></param>
<param><key>freq1</key><value>freq</value></param>
<param><key>gain_mode1</key><value>False</value></param>
<param><key>iq_balance_mode1</key><value>0</value></param>
<param><key>lna_gain1</key><value>30</value></param>
<param><key>pga_gain1</key><value>0</value></param>
<param><key>tia_gain1</key><value>12</value></param>
<param><key>args</key><value></value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>linrad_send_raw16</key>
<param><key>id</key><value>linrad_send_raw16_0</value></param>
<param><key>base_port</key><value>50000</value></param>
<param><key>bufsize</key><value>0x1000</value></param>
<param><key>ip</key><value>"127.0.0.1"</value></param>
<param><key>passband_center</key><value>freq * 1e-6</value></param>
</block>
<block>
<key>linrad_server</key>
<param><key>id</key><value>linrad_server_0</value></param>
<param><key>ad</key><value>4</value></param>
<param><key>buf</key><value>0x1000</value></param>
<param><key>dword</key><value>False</value></param>
<param><key>iq</key><value>True</value></param>
<param><key>ip</key><value>"0.0.0.0"</value></param>
<param><key>rf</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>blocks_interleave_0</source_block_id><sink_block_id>linrad_send_raw16_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleave_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleave_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleave_0_0_1</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_interleave_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0</source_block_id><sink_block_id>blocks_interleave_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_1</source_block_id><sink_block_id>blocks_interleave_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_1_0</source_block_id><sink_block_id>blocks_interleave_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_1_1</source_block_id><sink_block_id>blocks_interleave_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_1_1_0</source_block_id><sink_block_id>blocks_interleave_0_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>limesdr_rx_source_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>limesdr_rx_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>limesdr_rx_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>limesdr_rx_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>limesdr_rx_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>limesdr_rx_source_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>limesdr_rx_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>limesdr_rx_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>limesdr_rx_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_1_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>limesdr_rx_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
</flow_graph>
