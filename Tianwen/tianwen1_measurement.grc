options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: tianwen1_measurement
    output_language: python
    title: Tianwen-1 signal measurement
  states: {}

blocks:
- name: bandtaps
  id: variable
  parameters:
    value: np.array(firdes.band_pass(1, samp_rate,499e3,501e3,1e3)) + np.array(firdes.band_pass(1, samp_rate,999e3,1001e3,1e3))
  states: {}
- name: baudrate
  id: variable
  parameters:
    value: 16.384e3
  states: {}
- name: pll_bw
  id: variable
  parameters:
    value: '500'
  states: {}
- name: pll_limit
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2500000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/baudrate
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: 2*pi*pll_limit/samp_rate
    min_freq: '-2*pi*pll_limit/samp_rate'
    w: 2*pi*pll_bw/samp_rate
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-4'
    type: float
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 4/32
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/4*1e6
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (-1,)*8 + (1,)*16 + (-1,)*8
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /mnt/disk/tianwen1/SDRSharp_20200726_074720Z_8430904830Hz_IQ_2M5_dec1.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '10000'
    long_form: 'True'
    type: ff
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.001'
    osps: '16'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_rate/(2*65536)
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.005'
    max_dev: '0.001'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '32'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '4'
    taps: np.ones(128)/128
    type: fff
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: np.concatenate((np.zeros(bandtaps.size//2), [1], np.zeros(bandtaps.size//2))) - bandtaps
    type: fff
  states: {}
- name: fir_filter_xxx_1_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: bandtaps
    type: fff
  states: {}
- name: fir_filter_xxx_1_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: bandtaps
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/20*0.95
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/20*0.1
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/10*0.95
    decim: '5'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: samp_rate/10*0.1
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'tab@0 : 0,1'
    legend: 'False'
    name: Phase modulation constellation
    size: '1000'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate/10
    fc: '0'
    fftsize: '4096'
    gui_hint: 'tab@0 : 0,0'
    label: PSD
    legend: 'False'
    name: PLL output
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-10'
    ymin: '-70'
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    alpha2: '0.3'
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    gui_hint: 'tab@1 : 0,0'
    label: PSD
    label1: Phase modulation
    label2: Amplitude modulation
    name: Spectrum
    nconnections: '2'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-10'
    ymin: '-80'
  states: {}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    gui_hint: 'tab@2 : 1,0,1,2'
    label: PSD
    label1: Phase modulation
    name: Spectrum
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-30'
    ymin: '-75'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 'tab@3 : 1,1'
    label1: Symbols amplitude
    name: ''
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 'tab@3 : 1,0'
    label1: Symbol clock fractional error
    name: ''
    type: float
    unit1: ppm
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'tab@1 : 0,1'
    label1: Data subcarrier
    label2: Ranging tone
    name: Time domain signals
    nconnections: '2'
    size: '1000'
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'tab@4 : 0,0'
    label1: Amplitude modulation
    label2: Phase modulation
    name: Modulation at ranging tone and harmonics
    nconnections: '2'
    size: '100'
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'tab@2 : 0,0'
    label1: Data + Subcarrier
    label2: Reference subcarrier
    name: Subcarrier locked
    nconnections: '2'
    size: '256'
    srate: 2**17*16
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'tab@2 : 0,1'
    label1: Data
    label2: Reference subcarrier
    name: Subcarrier locked & wiped
    nconnections: '2'
    size: '256'
    srate: 2**17*16
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'tab@3 : 0,1'
    legend: 'False'
    marker1: '0'
    name: Symbols
    size: '1024'
    srate: samp_rate
    style1: '0'
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'tab@3 : 0,0'
    name: Subcarrier cycles per symbol
    size: '1024'
    srate: samp_rate
    type: float
    ymax: 4+4e-5
    ymin: 4-4e-5
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-5'
    reference: '1.0'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1e-3'
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.01'
    type: float
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Phase modulation
    label1: Modulating signal
    label2: Data subcarrier
    label3: Data modulation
    label4: Amplitude modulation
    num_tabs: '5'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: pll_out
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: data_subcarrier
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: subcarrier_wipe
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: pll_out
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: data_subcarrier
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: subcarrier_wipe
  states: {}

connections:
- [analog_pll_carriertracking_cc_0, '0', low_pass_filter_0, '0']
- [analog_pll_carriertracking_cc_0, '0', qtgui_const_sink_x_0, '0']
- [analog_pll_carriertracking_cc_0, '0', virtual_sink_0, '0']
- [blocks_abs_xx_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_complex_to_arg_0, '0', fir_filter_xxx_1, '0']
- [blocks_complex_to_arg_0, '0', fir_filter_xxx_1_0, '0']
- [blocks_complex_to_arg_0, '0', low_pass_filter_0_0, '0']
- [blocks_complex_to_arg_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_complex_to_mag_squared_0, '0', dc_blocker_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', fir_filter_xxx_1_0_0, '0']
- [blocks_float_to_complex_0, '0', satellites_rms_agc_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_multiply_const_vxx_1, '0', single_pole_iir_filter_xx_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_2, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_vector_source_x_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_vector_source_x_0, '0', qtgui_time_sink_x_1_0, '1']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [dc_blocker_xx_0, '0', qtgui_freq_sink_x_0_1, '1']
- [digital_symbol_sync_xx_0, '0', blocks_multiply_xx_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_1, '0']
- [digital_symbol_sync_xx_0_0, '0', blocks_abs_xx_0, '0']
- [digital_symbol_sync_xx_0_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [digital_symbol_sync_xx_0_0, '1', blocks_null_sink_1, '0']
- [digital_symbol_sync_xx_0_0, '2', blocks_null_sink_1, '1']
- [digital_symbol_sync_xx_0_0, '3', blocks_multiply_const_vxx_0, '0']
- [fir_filter_xxx_0, '0', digital_symbol_sync_xx_0_0, '0']
- [fir_filter_xxx_1, '0', qtgui_time_sink_x_0, '0']
- [fir_filter_xxx_1, '0', virtual_sink_1, '0']
- [fir_filter_xxx_1_0, '0', qtgui_time_sink_x_0, '1']
- [fir_filter_xxx_1_0, '0', qtgui_time_sink_x_0_1, '1']
- [fir_filter_xxx_1_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [satellites_rms_agc_0, '0', analog_pll_carriertracking_cc_0, '0']
- [single_pole_iir_filter_xx_0, '0', qtgui_number_sink_0, '0']
- [single_pole_iir_filter_xx_0_0, '0', qtgui_number_sink_0_0, '0']
- [virtual_source_0, '0', blocks_complex_to_arg_0, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_1, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_2, '0', fir_filter_xxx_0, '0']

metadata:
  file_format: 1
