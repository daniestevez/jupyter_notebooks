options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: hl2_freq
    output_language: python
    title: Hermes-Lite2 frequency measurement
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: samp_rate//6000
  states: {}
- name: loop_bw
  id: variable
  parameters:
    value: '10'
  states: {}
- name: output_rate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48000*8
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: np.pi
    min_freq: '-np.pi'
    w: 2*np.pi*loop_bw*decim/samp_rate
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: f'/home/daniel/hl2-freq-meas/phase_{datetime.datetime.utcnow().isoformat()}.f32'
    type: float
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate/(decim*output_rate))
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: np.exp(-2j*np.pi*np.arange(samp_rate//1000)*10/(samp_rate//1000))
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: decim
    taps: firdes.low_pass(3e3, 1, 0.45/decim, 0.1/decim)
    type: ccc
  states: {}
- name: hermeslite2_NB_0
  id: hermeslite2_NB
  parameters:
    AGC: 'False'
    Intfc: '"enp5s0"'
    LNAG: '18'
    MACAddr: '"*"'
    PA: 'False'
    PTTRx: 'True'
    PTTTx: 'True'
    PTTmode: '0'
    Q5: 'False'
    Rx0F: 10000000-10000
    Rx1F: '7200000'
    Rx2F: '7200000'
    Rx3F: '7200000'
    Rx4F: '7200000'
    Rx5F: '7200000'
    Rx6F: '7200000'
    Rx7F: '7200000'
    RxSmp: '384000'
    TxDrive: '0'
    TxF: 10000000-10000
    Verbose: '0'
    num_outputs: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import datetime
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 10e6-10e3
    fftsize: '4096'
    gui_hint: 0,0,1,1
    name: RX full bandwidth
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-60'
    ymin: '-150'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decim
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,1,1,1
    name: 6kHz slice centred on 10MHz
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,2
    marker1: '0'
    size: '1000'
    srate: output_rate
    type: float
    ymax: '-4'
    ymin: '4'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: phase
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: phase
  states: {}

connections:
- [analog_pll_refout_cc_0, '0', blocks_complex_to_magphase_0, '0']
- [blocks_complex_to_magphase_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_magphase_0, '1', virtual_sink_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_file_sink_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', fir_filter_xxx_0, '0']
- [blocks_null_source_0, '0', hermeslite2_NB_0, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_0, '1']
- [fir_filter_xxx_0, '0', analog_pll_refout_cc_0, '0']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [hermeslite2_NB_0, '0', blocks_multiply_xx_0, '0']
- [hermeslite2_NB_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', blocks_keep_one_in_n_0, '0']

metadata:
  file_format: 1
