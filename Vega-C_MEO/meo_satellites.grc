options:
  parameters:
    author: daniel
    generate_options: qt_gui
    id: meo_satellites
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: dec
  id: variable
  parameters:
    value: dec1 * dec2
  states: {}
- name: dec1
  id: variable
  parameters:
    value: '50'
  states: {}
- name: dec2
  id: variable
  parameters:
    value: '2'
  states: {}
- name: digital_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: lowpass_taps
  id: variable
  parameters:
    value: firdes.low_pass(digital_gain, 1, 0.45/dec2, 0.1/dec2)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: timestamp
  id: variable
  parameters:
    value: datetime.datetime.utcnow().isoformat().split('.')[0].replace(':', '_')
  states: {}
- name: tune_freq
  id: variable
  parameters:
    value: 436.520e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0.1'
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: 2**15
    vector_output: 'True'
  states: {}
- name: blocks_complex_to_interleaved_short_0_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: 2**15
    vector_output: 'True'
  states: {}
- name: blocks_complex_to_interleaved_short_0_1
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: 2**15
    vector_output: 'True'
  states: {}
- name: blocks_complex_to_interleaved_short_0_2
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: 2**15
    vector_output: 'True'
  states: {}
- name: blocks_complex_to_interleaved_short_0_2_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: 2**15
    vector_output: 'True'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: f'CELESTA_{timestamp}.ci16'
    max_seg_size: int(samp_rate/dec*100)
    rel_rate: 1/dec
    samp_rate: samp_rate/dec
    type: short
    vlen: '2'
  states: {}
- name: blocks_file_meta_sink_0_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: f'MTCube2_{timestamp}.ci16'
    max_seg_size: int(samp_rate/dec*100)
    rel_rate: 1/dec
    samp_rate: samp_rate/dec
    type: short
    vlen: '2'
  states: {}
- name: blocks_file_meta_sink_0_1
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: f'GREENCUBE_{timestamp}.ci16'
    max_seg_size: int(samp_rate/dec*100)
    rel_rate: 1/dec
    samp_rate: samp_rate/dec
    type: short
    vlen: '2'
  states: {}
- name: blocks_file_meta_sink_0_2
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: f'ASTROBIO_{timestamp}.ci16'
    max_seg_size: int(samp_rate/dec*100)
    rel_rate: 1/dec
    samp_rate: samp_rate/dec
    type: short
    vlen: '2'
  states: {}
- name: blocks_file_meta_sink_0_2_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: f'ASTROBIO2_{timestamp}.ci16'
    max_seg_size: int(samp_rate/dec*100)
    rel_rate: 1/dec
    samp_rate: samp_rate/dec
    type: short
    vlen: '2'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: dec2
    taps: lowpass_taps
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: dec2
    taps: lowpass_taps
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: dec2
    taps: lowpass_taps
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: dec2
    taps: lowpass_taps
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: dec2
    taps: lowpass_taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 436.5e6 - tune_freq
    comment: CELESTA
    decim: dec1
    samp_rate: samp_rate
    taps: firdes.low_pass(1, 1, 0.45/dec, 1/dec1 - 2*0.45/dec)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 436.75e6 - tune_freq
    comment: MTCube 2
    decim: dec1
    samp_rate: samp_rate
    taps: firdes.low_pass(1, 1, 0.45/dec, 1/dec1 - 2*0.45/dec)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 435.310e6 - tune_freq
    comment: GREENCUBE
    decim: dec1
    samp_rate: samp_rate
    taps: firdes.low_pass(1, 1, 0.45/dec, 1/dec1 - 2*0.45/dec)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 437.425e6 - tune_freq
    comment: ASTROBIO
    decim: dec1
    samp_rate: samp_rate
    taps: firdes.low_pass(1, 1, 0.45/dec, 1/dec1 - 2*0.45/dec)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 435.600e6 - tune_freq
    comment: ASTROBIO 2
    decim: dec1
    samp_rate: samp_rate
    taps: firdes.low_pass(1, 1, 0.45/dec, 1/dec1 - 2*0.45/dec)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import datetime
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/dec
    fc: '0'
    fftsize: '4096'
    nconnections: '5'
    type: complex
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    size: '40000'
    type: float
    xmax: '0.1'
    xmin: '-0.1'
  states: {}
- name: satellites_doppler_correction_0
  id: satellites_doppler_correction
  parameters:
    file: /home/daniel/meo-satellites/CELESTA_doppler.txt
    samp_rate: samp_rate/dec1
    t0: '0'
  states: {}
- name: satellites_doppler_correction_0_0
  id: satellites_doppler_correction
  parameters:
    file: /home/daniel/meo-satellites/MTCube-2_doppler.txt
    samp_rate: samp_rate/dec1
    t0: '0'
  states: {}
- name: satellites_doppler_correction_0_1
  id: satellites_doppler_correction
  parameters:
    file: /home/daniel/meo-satellites/GREENCUBE_doppler.txt
    samp_rate: samp_rate/dec1
    t0: '0'
  states: {}
- name: satellites_doppler_correction_0_2
  id: satellites_doppler_correction
  parameters:
    file: /home/daniel/meo-satellites/ASTROBIOCUBESAT_doppler.txt
    samp_rate: samp_rate/dec1
    t0: '0'
  states: {}
- name: satellites_doppler_correction_0_3
  id: satellites_doppler_correction
  parameters:
    file: /home/daniel/meo-satellites/ASTROBIOCUBESAT_doppler.txt
    samp_rate: samp_rate/dec1
    t0: '0'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 436.5e6
    gain0: '30'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: tune_freq
    gain0: '76'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', uhd_usrp_sink_0, '0']
- [blocks_complex_to_interleaved_short_0, '0', blocks_file_meta_sink_0, '0']
- [blocks_complex_to_interleaved_short_0_0, '0', blocks_file_meta_sink_0_0, '0']
- [blocks_complex_to_interleaved_short_0_1, '0', blocks_file_meta_sink_0_1, '0']
- [blocks_complex_to_interleaved_short_0_2, '0', blocks_file_meta_sink_0_2, '0']
- [blocks_complex_to_interleaved_short_0_2_0, '0', blocks_file_meta_sink_0_2_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_histogram_sink_x_0, '0']
- [fir_filter_xxx_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [fir_filter_xxx_0, '0', blocks_complex_to_real_0, '0']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [fir_filter_xxx_0_0, '0', blocks_complex_to_interleaved_short_0_0, '0']
- [fir_filter_xxx_0_0, '0', qtgui_freq_sink_x_0, '1']
- [fir_filter_xxx_0_0_0, '0', blocks_complex_to_interleaved_short_0_1, '0']
- [fir_filter_xxx_0_0_0, '0', qtgui_freq_sink_x_0, '2']
- [fir_filter_xxx_0_0_0_0, '0', blocks_complex_to_interleaved_short_0_2, '0']
- [fir_filter_xxx_0_0_0_0, '0', qtgui_freq_sink_x_0, '3']
- [fir_filter_xxx_0_0_0_0_0, '0', blocks_complex_to_interleaved_short_0_2_0, '0']
- [fir_filter_xxx_0_0_0_0_0, '0', qtgui_freq_sink_x_0, '4']
- [freq_xlating_fir_filter_xxx_0, '0', satellites_doppler_correction_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', satellites_doppler_correction_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', satellites_doppler_correction_0_1, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0, '0', satellites_doppler_correction_0_2, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0_0, '0', satellites_doppler_correction_0_3, '0']
- [satellites_doppler_correction_0, '0', fir_filter_xxx_0, '0']
- [satellites_doppler_correction_0_0, '0', fir_filter_xxx_0_0, '0']
- [satellites_doppler_correction_0_1, '0', fir_filter_xxx_0_0_0, '0']
- [satellites_doppler_correction_0_2, '0', fir_filter_xxx_0_0_0_0, '0']
- [satellites_doppler_correction_0_3, '0', fir_filter_xxx_0_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
