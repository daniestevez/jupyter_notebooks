options:
  parameters:
    author: daniel
    generate_options: no_gui
    id: waterfall
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: nfft
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: waterfall.f32
    type: float
    vlen: nfft
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/meo-satellites/CELESTA_2022-07-24T18_47_38.ci16
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1/nfft**2]*nfft'
    type: float
    vlen: nfft
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
