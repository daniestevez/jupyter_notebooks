options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: hades_decimate
    output_language: python
    run_options: run
    title: HADES-D decimate recording
  states: {}

blocks:
- name: dec
  id: variable
  parameters:
    value: '125'
  states: {}
- name: filename
  id: variable
  parameters:
    value: '''HADES-D_2023-12-09T11_14_50.sigmf-data'''
  states: {}
- name: filename
  id: variable
  parameters:
    value: '''HADES-D_2023-12-09T11_20_03.sigmf-data'''
  states: {state: disabled}
- name: filename_out
  id: variable
  parameters:
    value: filename.split('.')[0] + '_32ksps.sigmf-data'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: start_time
  id: variable
  parameters:
    value: '1702120490.3592431562500000'
  states: {}
- name: start_time
  id: variable
  parameters:
    value: '1702120803.4641939375000000'
  states: {state: disabled}
- name: tle_time_error
  id: variable
  parameters:
    value: '-62'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filename_out
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: filename
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 166e3
    decim: dec
    samp_rate: samp_rate
    taps: firdes.low_pass(1, 1, 0.5/dec, 0.05/dec)
    type: ccc
  states: {}
- name: satellites_doppler_correction_0
  id: satellites_doppler_correction
  parameters:
    file: hades-d_doppler_1702120490.txt
    samp_rate: samp_rate
    t0: start_time + tle_time_error
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', satellites_doppler_correction_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_file_sink_0, '0']
- [satellites_doppler_correction_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
