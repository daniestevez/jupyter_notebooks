options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: hades_fsk_demod
    output_language: python
    run_options: run
    title: HADES-D FSK demodulate
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '50'
  states: {}
- name: dec
  id: variable
  parameters:
    value: samp_rate // (baudrate * sps)
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '550'
  states: {}
- name: freq_error
  id: variable
  parameters:
    value: '-1.3e3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sideband_filter
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, 200, 25)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: HADES-D_2023-12-09T11_20_03_32ksps.sigmf-data
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    comment: Low tone
    phase_inc: '-2 * np.pi * (freq_error - deviation) / samp_rate'
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    comment: High tone
    phase_inc: '-2 * np.pi * (freq_error + deviation) / samp_rate'
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate * 30
    type: complex
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.01'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: dec
    taps: sideband_filter
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: dec
    taps: sideband_filter
    type: ccc
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1] * sps'
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    size: 60 * baudrate
    srate: samp_rate
    style1: '0'
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}
- name: satellites_hades_deframer_0
  id: satellites_hades_deframer
  parameters:
    threshold: '0'
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '3e-2'
    reference: '1.0'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_sub_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_complex_to_real_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_file_source_0, '0', blocks_rotator_cc_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_complex_0, '0', satellites_rms_agc_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_rotator_cc_0, '0', fir_filter_xxx_0, '0']
- [blocks_rotator_cc_0_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_sub_xx_0, '0', fir_filter_xxx_1, '0']
- [blocks_throttle2_0, '0', blocks_rotator_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', satellites_hades_deframer_0, '0']
- [fir_filter_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fir_filter_xxx_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [fir_filter_xxx_1, '0', blocks_float_to_complex_0, '0']
- [satellites_hades_deframer_0, out, satellites_hexdump_sink_0, in]
- [satellites_rms_agc_0, '0', blocks_complex_to_real_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
