options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: hades_fm_demod
    output_language: python
    run_options: run
    title: HADES-D FM demodulate
  states: {}

blocks:
- name: freq_error
  id: variable
  parameters:
    value: '-1.3e3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '0.25'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: HADES-D_2023-12-09T11_20_03_32ksps.sigmf-data
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-2 * np.pi * freq_error / samp_rate'
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: hades_fm_demod.wav
    format: FORMAT_WAV
    samp_rate: samp_rate // 4
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: samp_rate // (4 * 100)
    long_form: 'True'
    type: ff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '3250'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '3100'
    decim: '4'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_1, '0']
- [blocks_file_source_0, '0', blocks_rotator_cc_0, '0']
- [blocks_rotator_cc_0, '0', low_pass_filter_0, '0']
- [dc_blocker_xx_0, '0', blocks_wavfile_sink_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_1, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
