options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: dme_limesdr_record
    output_language: python
    title: DME LimeSDR recorder
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: utcnow
  id: variable
  parameters:
    value: datetime.datetime.utcnow().isoformat()
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: (1 + 1j)/2**12
    type: complex
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: (1 + 1j)/2**12
    type: complex
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: 2**15
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_short_0_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: 2**15
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/test_capture.c64
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: f'/mnt/CNR_VOR_ground_{utcnow}.sigmf-data'
    type: short
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: f'/mnt/CNR_VOR_aircraft_{utcnow}.sigmf-data'
    type: short
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(10 * samp_rate)
    type: complex
  states: {state: disabled}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: int(10 * samp_rate)
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {state: disabled}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {state: disabled}
- name: blocks_probe_rate_0_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1/6] * 6'
    type: fff
  states: {state: disabled}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1/6] * 6'
    type: fff
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: f_offset
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, 1, 0.5/decim, 0.45/decim)
    type: ccf
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-f_offset'
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, 1, 0.5/decim, 0.45/decim)
    type: ccf
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import datetime
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 70e6
    analog_bandw_ch1: 70e6
    calibr_bandw_ch0: 70e6
    calibr_bandw_ch1: 70e6
    ch_align: 'False'
    channel_mode: '2'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    filename: limesdr_config.ini
    lna_path_ch0: '2'
    oversample: '0'
    rf_freq: 100e6
    samp_rate: '1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '200000'
    srate: samp_rate
    tr_level: '-25'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '-10'
    ymin: '-50'
  states: {state: disabled}

connections:
- [blocks_add_const_vxx_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_complex_to_interleaved_short_0_0, '0']
- [blocks_add_const_vxx_0_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_complex_to_interleaved_short_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_complex_to_interleaved_short_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_complex_to_mag_squared_1, '0', fir_filter_xxx_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_probe_rate_0_0, rate, blocks_message_debug_0, log]
- [fir_filter_xxx_0, '0', blocks_nlog10_ff_0, '0']
- [fir_filter_xxx_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_squared_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_file_sink_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_file_sink_0_0_0, '0']
- [limesdr_source_0, '0', blocks_add_const_vxx_0, '0']
- [limesdr_source_0, '0', blocks_complex_to_mag_squared_1, '0']
- [limesdr_source_0, '0', blocks_head_0, '0']
- [limesdr_source_0, '0', blocks_probe_rate_0, '0']
- [limesdr_source_0, '0', blocks_tag_debug_0, '0']
- [limesdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [limesdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [limesdr_source_0, '1', blocks_add_const_vxx_0_0, '0']
- [limesdr_source_0, '1', blocks_complex_to_mag_squared_0, '0']
- [limesdr_source_0, '1', blocks_probe_rate_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
