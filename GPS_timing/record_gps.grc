options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: record_gps
    output_language: python
    run_options: run
    title: Record GPS
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: /home/daniel/gps_timing/gps_recording.cs16
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: short
    vlen: '2'
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(15 * samp_rate)
    type: short
    vlen: '2'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      print('Setting time source to internal')
      time.sleep(1)
      self.uhd_usrp_source_0.set_time_source('internal', 0)
      time.sleep(1)
    section: main_after_init
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: 1575.42e6
    gain0: '80'
    samp_rate: samp_rate
    sync: pc_clock_next_pps
    time_source0: external
    type: sc16
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_meta_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
