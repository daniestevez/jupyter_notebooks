options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: convert_gps_8bit
    output_language: python
    run_options: run
    title: Convert GPS recording to 8 bit IQ
  states: {}

blocks:
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/daniel/gps_timing/gps_recording.cs8
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/gps_timing/gps_recording.cs16
    repeat: 'False'
    type: short
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.022'
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_short_to_float_0, '0']
- [blocks_float_to_char_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_char_0, '0']
- [blocks_short_to_float_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
