options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: hl2_freq
    output_language: python
    title: Hermes-Lite2 frequency measurement
  states: {}

blocks:
- name: dec_60_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 0.48/60
    gain: '1.0'
    samp_rate: '1'
    width: 0.04/60
    win: firdes.WIN_HAMMING
  states: {}
- name: decim
  id: variable
  parameters:
    value: samp_rate//12000
  states: {}
- name: gain
  id: variable
  parameters:
    value: '500'
  states: {}
- name: loop_bw
  id: variable
  parameters:
    value: '10'
  states: {}
- name: output_rate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0_0_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0_0_0_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0_0_0_0_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: f'/home/daniel/hl2-freq-meas/iq_5000kHz_{datetime.datetime.utcnow().isoformat()}.i16'
    type: short
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: f'/home/daniel/hl2-freq-meas/iq_10000kHz_{datetime.datetime.utcnow().isoformat()}.i16'
    type: short
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: f'/home/daniel/hl2-freq-meas/iq_15000kHz_{datetime.datetime.utcnow().isoformat()}.i16'
    type: short
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: f'/home/daniel/hl2-freq-meas/iq_4996kHz_{datetime.datetime.utcnow().isoformat()}.i16'
    type: short
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: f'/home/daniel/hl2-freq-meas/iq_9996kHz_{datetime.datetime.utcnow().isoformat()}.i16'
    type: short
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: f'/home/daniel/hl2-freq-meas/iq_14996kHz_{datetime.datetime.utcnow().isoformat()}.i16'
    type: short
    unbuffered: 'True'
  states: {}
- name: blocks_float_to_short_0_0_0
  id: blocks_float_to_short
  parameters:
    scale: 2**15
  states: {}
- name: blocks_float_to_short_0_0_0_0
  id: blocks_float_to_short
  parameters:
    scale: 2**15
  states: {}
- name: blocks_float_to_short_0_0_0_0_0
  id: blocks_float_to_short
  parameters:
    scale: 2**15
  states: {}
- name: blocks_float_to_short_0_0_0_0_0_0
  id: blocks_float_to_short
  parameters:
    scale: 2**15
  states: {}
- name: blocks_float_to_short_0_0_0_0_0_0_0
  id: blocks_float_to_short
  parameters:
    scale: 2**15
  states: {}
- name: blocks_float_to_short_0_0_0_0_0_0_0_0
  id: blocks_float_to_short
  parameters:
    scale: 2**15
  states: {}
- name: blocks_float_to_short_0_1
  id: blocks_float_to_short
  parameters:
    scale: 2**15
  states: {}
- name: blocks_float_to_short_0_1_0
  id: blocks_float_to_short
  parameters:
    scale: 2**15
  states: {}
- name: blocks_float_to_short_0_1_0_0
  id: blocks_float_to_short
  parameters:
    scale: 2**15
  states: {}
- name: blocks_float_to_short_0_1_0_0_0
  id: blocks_float_to_short
  parameters:
    scale: 2**15
  states: {}
- name: blocks_float_to_short_0_1_0_0_0_0
  id: blocks_float_to_short
  parameters:
    scale: 2**15
  states: {}
- name: blocks_float_to_short_0_1_0_0_0_0_0
  id: blocks_float_to_short
  parameters:
    scale: 2**15
  states: {}
- name: blocks_interleave_1_0
  id: blocks_interleave
  parameters:
    type: short
  states: {}
- name: blocks_interleave_1_0_0
  id: blocks_interleave
  parameters:
    type: short
  states: {}
- name: blocks_interleave_1_0_0_0
  id: blocks_interleave
  parameters:
    type: short
  states: {}
- name: blocks_interleave_1_0_0_0_0
  id: blocks_interleave
  parameters:
    type: short
  states: {}
- name: blocks_interleave_1_0_0_0_0_0
  id: blocks_interleave
  parameters:
    type: short
  states: {}
- name: blocks_interleave_1_0_0_0_0_0_0
  id: blocks_interleave
  parameters:
    type: short
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: np.exp(1j*2*np.pi*np.arange(3)*4/12)
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: decim
    taps: firdes.low_pass(gain, 1, 0.45/decim, 0.1/decim)
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: decim
    taps: firdes.low_pass(gain, 1, 0.45/decim, 0.1/decim)
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: decim
    taps: firdes.low_pass(gain, 1, 0.45/decim, 0.1/decim)
    type: ccc
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '60'
    taps: dec_60_taps
    type: ccc
  states: {}
- name: fir_filter_xxx_1_0
  id: fir_filter_xxx
  parameters:
    decim: '60'
    taps: dec_60_taps
    type: ccc
  states: {}
- name: fir_filter_xxx_1_0_0
  id: fir_filter_xxx
  parameters:
    decim: '60'
    taps: dec_60_taps
    type: ccc
  states: {}
- name: fir_filter_xxx_1_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: '60'
    taps: dec_60_taps
    type: ccc
  states: {}
- name: fir_filter_xxx_1_0_1
  id: fir_filter_xxx
  parameters:
    decim: '60'
    taps: dec_60_taps
    type: ccc
  states: {}
- name: fir_filter_xxx_1_1
  id: fir_filter_xxx
  parameters:
    decim: '60'
    taps: dec_60_taps
    type: ccc
  states: {}
- name: hermeslite2_NB_0
  id: hermeslite2_NB
  parameters:
    AGC: 'False'
    Intfc: '"enp5s0"'
    LNAG: '18'
    MACAddr: '"*"'
    PA: 'False'
    PTTRx: 'True'
    PTTTx: 'True'
    PTTmode: '0'
    Q5: 'False'
    Rx0F: '5000000'
    Rx1F: '10000000'
    Rx2F: '15000000'
    Rx3F: '7200000'
    Rx4F: '7200000'
    Rx5F: '7200000'
    Rx6F: '7200000'
    Rx7F: '7200000'
    RxSmp: '48000'
    TxDrive: '0'
    TxF: '10000000'
    Verbose: '0'
    num_outputs: '3'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import datetime
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decim
    fc: '0'
    fftsize: '4096'
    label1: 5 MHz
    label2: 10 MHz
    label3: 15 MHz
    name: ''
    nconnections: '3'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_complex_to_float_0_0, '0', blocks_float_to_short_0_1, '0']
- [blocks_complex_to_float_0_0, '1', blocks_float_to_short_0_0_0, '0']
- [blocks_complex_to_float_0_0_0, '0', blocks_float_to_short_0_1_0, '0']
- [blocks_complex_to_float_0_0_0, '1', blocks_float_to_short_0_0_0_0, '0']
- [blocks_complex_to_float_0_0_0_0, '0', blocks_float_to_short_0_1_0_0, '0']
- [blocks_complex_to_float_0_0_0_0, '1', blocks_float_to_short_0_0_0_0_0, '0']
- [blocks_complex_to_float_0_0_0_0_0, '0', blocks_float_to_short_0_1_0_0_0, '0']
- [blocks_complex_to_float_0_0_0_0_0, '1', blocks_float_to_short_0_0_0_0_0_0, '0']
- [blocks_complex_to_float_0_0_0_0_0_0, '0', blocks_float_to_short_0_1_0_0_0_0, '0']
- [blocks_complex_to_float_0_0_0_0_0_0, '1', blocks_float_to_short_0_0_0_0_0_0_0, '0']
- [blocks_complex_to_float_0_0_0_0_0_0_0, '0', blocks_float_to_short_0_1_0_0_0_0_0, '0']
- [blocks_complex_to_float_0_0_0_0_0_0_0, '1', blocks_float_to_short_0_0_0_0_0_0_0_0, '0']
- [blocks_float_to_short_0_0_0, '0', blocks_interleave_1_0, '1']
- [blocks_float_to_short_0_0_0_0, '0', blocks_interleave_1_0_0, '1']
- [blocks_float_to_short_0_0_0_0_0, '0', blocks_interleave_1_0_0_0, '1']
- [blocks_float_to_short_0_0_0_0_0_0, '0', blocks_interleave_1_0_0_0_0, '1']
- [blocks_float_to_short_0_0_0_0_0_0_0, '0', blocks_interleave_1_0_0_0_0_0, '1']
- [blocks_float_to_short_0_0_0_0_0_0_0_0, '0', blocks_interleave_1_0_0_0_0_0_0, '1']
- [blocks_float_to_short_0_1, '0', blocks_interleave_1_0, '0']
- [blocks_float_to_short_0_1_0, '0', blocks_interleave_1_0_0, '0']
- [blocks_float_to_short_0_1_0_0, '0', blocks_interleave_1_0_0_0, '0']
- [blocks_float_to_short_0_1_0_0_0, '0', blocks_interleave_1_0_0_0_0, '0']
- [blocks_float_to_short_0_1_0_0_0_0, '0', blocks_interleave_1_0_0_0_0_0, '0']
- [blocks_float_to_short_0_1_0_0_0_0_0, '0', blocks_interleave_1_0_0_0_0_0_0, '0']
- [blocks_interleave_1_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_interleave_1_0_0, '0', blocks_file_sink_0_0_0_0, '0']
- [blocks_interleave_1_0_0_0, '0', blocks_file_sink_0_0_0_0_0, '0']
- [blocks_interleave_1_0_0_0_0, '0', blocks_file_sink_0_0_0_0_0_0, '0']
- [blocks_interleave_1_0_0_0_0_0, '0', blocks_file_sink_0_0_0_0_0_0_0, '0']
- [blocks_interleave_1_0_0_0_0_0_0, '0', blocks_file_sink_0_0_0_0_0_0_0_0, '0']
- [blocks_multiply_xx_0, '0', fir_filter_xxx_1_0_1, '0']
- [blocks_multiply_xx_0_0, '0', fir_filter_xxx_1_1, '0']
- [blocks_multiply_xx_0_0_0, '0', fir_filter_xxx_1_0_0_0, '0']
- [blocks_null_source_0, '0', hermeslite2_NB_0, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_0_0_0, '1']
- [fir_filter_xxx_0, '0', blocks_multiply_xx_0, '0']
- [fir_filter_xxx_0, '0', fir_filter_xxx_1_0, '0']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [fir_filter_xxx_0_0, '0', blocks_multiply_xx_0_0, '0']
- [fir_filter_xxx_0_0, '0', fir_filter_xxx_1, '0']
- [fir_filter_xxx_0_0, '0', qtgui_freq_sink_x_0_0, '1']
- [fir_filter_xxx_0_0_0, '0', blocks_multiply_xx_0_0_0, '0']
- [fir_filter_xxx_0_0_0, '0', fir_filter_xxx_1_0_0, '0']
- [fir_filter_xxx_0_0_0, '0', qtgui_freq_sink_x_0_0, '2']
- [fir_filter_xxx_1, '0', blocks_complex_to_float_0_0_0, '0']
- [fir_filter_xxx_1_0, '0', blocks_complex_to_float_0_0, '0']
- [fir_filter_xxx_1_0_0, '0', blocks_complex_to_float_0_0_0_0, '0']
- [fir_filter_xxx_1_0_0_0, '0', blocks_complex_to_float_0_0_0_0_0_0_0, '0']
- [fir_filter_xxx_1_0_1, '0', blocks_complex_to_float_0_0_0_0_0, '0']
- [fir_filter_xxx_1_1, '0', blocks_complex_to_float_0_0_0_0_0_0, '0']
- [hermeslite2_NB_0, '0', fir_filter_xxx_0, '0']
- [hermeslite2_NB_0, '1', fir_filter_xxx_0_0, '0']
- [hermeslite2_NB_0, '2', fir_filter_xxx_0_0_0, '0']

metadata:
  file_format: 1
