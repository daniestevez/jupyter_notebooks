options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: usrp_sat_record
    output_language: python
    title: USRP satellite record
  states: {}

blocks:
- name: linrad_dec
  id: variable
  parameters:
    value: '16'
  states: {}
- name: linrad_freq
  id: variable
  parameters:
    value: 436.666e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: usrp_freq
  id: variable
  parameters:
    value: 436.5e6
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: 2**15
    vector_output: 'True'
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: f'/home/daniel/sat_recording_{datetime.datetime.utcnow().isoformat()}.bin'
    max_seg_size: int(10 * samp_rate)
    rel_rate: '1'
    samp_rate: samp_rate
    type: short
    vlen: '2'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: linrad_freq - usrp_freq
    decim: linrad_dec
    samp_rate: samp_rate
    taps: firdes.low_pass(1, 1, 0.5/linrad_dec, 0.1/linrad_dec)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import datetime
  states: {}
- name: linrad_send_raw16_0
  id: linrad_send_raw16
  parameters:
    base_port: '50000'
    bufsize: '0x1000'
    ip: '"127.0.0.1"'
    passband_center: linrad_freq * 1e-6
  states: {}
- name: linrad_server_0
  id: linrad_server
  parameters:
    ad: '2'
    buf: '0x1000'
    dword: 'False'
    ip: '"0.0.0.0"'
    iq: 'True'
    rf: '1'
    samp_rate: int(samp_rate/linrad_dec)
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: 2*samp_rate
    center_freq0: uhd.tune_request(usrp_freq, samp_rate/2)
    gain0: '76'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_complex_to_interleaved_short_0, '0', blocks_file_meta_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', linrad_send_raw16_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
