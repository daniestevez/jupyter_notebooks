options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: pll
    output_language: python
    title: PLL tracking of QO-100 CW carrier
  states: {}

blocks:
- name: cn0
  id: variable_qtgui_entry
  parameters:
    gui_hint: 5,1,1,1
    label: CN0 (dB)
    type: real
    value: '50'
  states: {}
- name: cutoff
  id: variable_qtgui_entry
  parameters:
    gui_hint: 4,1,1,1
    label: Filter cutoff (Hz)
    type: real
    value: '25'
  states: {}
- name: lowpass_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '30'
    gain: 1.0 / math.sqrt(505)
    samp_rate: samp_rate
    width: '10'
    win: firdes.WIN_HAMMING
  states: {}
- name: noise_voltage
  id: variable
  parameters:
    value: math.sqrt(0.5*100)*10**(-cn0/20)
  states: {}
- name: pll_bw
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,1,1,1
    label: PLL bandwidth (Hz)
    type: real
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_voltage
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: '3.14'
    min_freq: '-3.14'
    w: 2 * math.pi * pll_bw / 100
  states: {}
- name: analog_pll_freqdet_cf_0
  id: analog_pll_freqdet_cf
  parameters:
    max_freq: '3.14'
    min_freq: '-3.14'
    w: 2 * math.pi * pll_bw / 100
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: '3.14'
    min_freq: '-3.14'
    w: 2 * math.pi * pll_bw / 100
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/cw_beacon_1ksps.c64
    length: '11000'
    offset: '89250'
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '10000'
    type: complex
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '10000'
    max_iter: '4000'
    scale: 1/10000
    type: float
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/10000
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-42'
    decim: '10'
    samp_rate: samp_rate
    taps: lowpass_taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/10
    type: fir_filter_ccf
    width: '1'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/10
    type: fir_filter_ccf
    width: '1'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,0,4,1
    label1: '"Noise-free signal after PLL"'
    name: ''
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/10
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,1
    label1: Original signal
    label2: Signal after PLL
    label3: Noise-free signal after PLL
    nconnections: '3'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 2,1,1,1
    label1: Signal power
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,1,1,1
    name: PLL frequency
    size: '3000'
    srate: samp_rate/10
    type: float
    ylabel: Frequency
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_pll_carriertracking_cc_0, '0', qtgui_freq_sink_x_0, '1']
- [analog_pll_freqdet_cf_0, '0', qtgui_time_sink_x_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_add_xx_0, '0', low_pass_filter_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_squared_1, '0', qtgui_number_sink_0_0, '0']
- [blocks_file_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_integrate_xx_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', qtgui_freq_sink_x_0, '2']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_mag_squared_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_add_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', low_pass_filter_0_0, '0']
- [low_pass_filter_0, '0', analog_pll_carriertracking_cc_0, '0']
- [low_pass_filter_0, '0', analog_pll_freqdet_cf_0, '0']
- [low_pass_filter_0, '0', analog_pll_refout_cc_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0_0, '0', blocks_multiply_conjugate_cc_0, '0']

metadata:
  file_format: 1
