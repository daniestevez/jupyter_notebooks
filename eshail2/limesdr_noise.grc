options:
  parameters:
    generate_options: no_gui
    id: limesdr_noise
    output_language: python
    realtime_scheduling: '1'
    run_options: run
  states: {}

blocks:
- name: tstamp
  id: variable
  parameters:
    value: '''{}''.format(datetime.datetime.utcnow().isoformat())'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: '''power_f32_{}''.format(tstamp)'
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /tmp/test.c64
    type: complex
  states: {state: disabled}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '600'
    type: float
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: '1000'
    type: float
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: 1392//2
    n: (24+1392)//2
    offset: 24//2
    type: short
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'False'
    ipaddr: 0.0.0.0
    port: '50100'
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import datetime
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_integrate_xx_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_file_sink_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_udp_source_0, '0', blocks_keep_m_in_n_0, '0']

metadata:
  file_format: 1
