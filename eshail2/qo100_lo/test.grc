<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test</value></param>
<param><key>author</key><value>Daniel Estevez EA4GPZ</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Test of the QO-100 LO stability</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cw_table</value></param>
<param><key>value</key><value>{'.' : [1,0], '-' : [1,1,1,0], ' ' : [0,0], '\t' : [0]*6}</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>f_cw</value></param>
<param><key>value</key><value>750e3</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>f_tune</value></param>
<param><key>value</key><value>-460</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filename</value></param>
<param><key>value</key><value>'/home/daniel/jupyter_notebooks/eshail2/qo100_lo/phase_10706MHz_{}.f32'.format(tstamp)</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>0.2</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>lowpass_taps</value></param>
<param><key>cutoff_freq</key><value>1e3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>100</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>lowpass_taps2</value></param>
<param><key>cutoff_freq</key><value>100</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>10</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>msg</value></param>
<param><key>value</key><value>'. .- ....- --. .--. --..\t..-. .-. . --.-\t- . ... -\t\t'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pll_bw</value></param>
<param><key>value</key><value>pll_bw_hz * 2 * math.pi / 2e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pll_bw_hz</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>600000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tstamp</value></param>
<param><key>value</key><value>'{}'.format(datetime.datetime.utcnow().isoformat())</value></param>
</block>
<block>
<key>analog_pll_refout_cc</key>
<param><key>id</key><value>analog_pll_refout_cc_0</value></param>
<param><key>w</key><value>pll_bw</value></param>
<param><key>max_freq</key><value>0.1</value></param>
<param><key>min_freq</key><value>-0.1</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>gain</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>f_cw - 750e3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>gain/2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>f_cw - 750e3 - 500</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0</value></param>
</block>
<block>
<key>blocks_complex_to_interleaved_short</key>
<param><key>id</key><value>blocks_complex_to_interleaved_short_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>vector_output</key><value>False</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>filename</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_interleaved_short_to_complex</key>
<param><key>id</key><value>blocks_interleaved_short_to_complex_0</value></param>
<param><key>vector_input</key><value>False</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>m</key><value>1392//2</value></param>
<param><key>n</key><value>(24+1392)//2</value></param>
<param><key>type</key><value>short</value></param>
<param><key>offset</key><value>24//2</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>n</key><value>20</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0</value></param>
<param><key>n</key><value>20</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>2**15</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>int(np.round(3000/12.5))</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0</value></param>
<param><key>ipaddr</key><value>eshail.lan.destevez.net</value></param>
<param><key>port</key><value>6969</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_0</value></param>
<param><key>ipaddr</key><value>239.255.0.0</value></param>
<param><key>eof</key><value>False</value></param>
<param><key>type</key><value>short</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>port</key><value>50100</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>np.concatenate([cw_table[c] for c in msg])</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>w</key><value>pll_bw</value></param>
<param><key>order</key><value>2</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0</value></param>
<param><key>center_freq</key><value>800e3 - 675e3 + f_tune</value></param>
<param><key>decim</key><value>150</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>lowpass_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_0</value></param>
<param><key>center_freq</key><value>f_cw - 750e3 + f_tune</value></param>
<param><key>decim</key><value>300</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>lowpass_taps2</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import datetime</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>50</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/200</value></param>
<param><key>width</key><value>10</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>size</key><value>3000</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>2000</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>100</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>6.5</value></param>
<param><key>ymin</key><value>-6.5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>100</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>6.5</value></param>
<param><key>ymin</key><value>-6.5</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>200</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rms_agc</key>
<param><key>id</key><value>rms_agc_0</value></param>
<param><key>alpha</key><value>1e-2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>reference</key><value>1</value></param>
</block>
<block>
<key>rms_agc</key>
<param><key>id</key><value>rms_agc_0_0</value></param>
<param><key>alpha</key><value>1e-2</value></param>
<param><key>reference</key><value>1</value></param>
</block>
<connection><source_block_id>analog_pll_refout_cc_0</source_block_id><sink_block_id>blocks_complex_to_arg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_interleaved_short_0</source_block_id><sink_block_id>blocks_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleave_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_short_to_complex_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_short_to_complex_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>blocks_interleaved_short_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_complex_to_interleaved_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0</source_block_id><sink_block_id>rms_agc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0</source_block_id><sink_block_id>rms_agc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rms_agc_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rms_agc_0_0</source_block_id><sink_block_id>analog_pll_refout_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rms_agc_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
