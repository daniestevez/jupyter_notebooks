options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: qo100_beacon_phase
    output_language: python
    title: QO-100 beacon phase measurement
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: baudrate_bpsk
  id: variable
  parameters:
    value: '800'
  states: {}
- name: decim1
  id: variable
  parameters:
    value: '25'
  states: {}
- name: decim2
  id: variable
  parameters:
    value: 100//decim1
  states: {}
- name: nfilt
  id: variable
  parameters:
    value: '64'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilt, nfilt, 1.0/sps, 0.2, int(ceil(15*sps*nfilt)))
  states: {}
- name: rrc_taps_bpsk
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilt, nfilt, 1.0/sps, 0.35, int(ceil(15*sps_bpsk*nfilt)))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '600000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/(decim1*decim2*baudrate)
  states: {}
- name: sps_bpsk
  id: variable
  parameters:
    value: samp_rate/(decim1*decim2*baudrate_bpsk)
  states: {}
- name: timestamp
  id: variable
  parameters:
    value: datetime.datetime.utcnow().isoformat()
  states: {}
- name: tune
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,0,1,3
    label: Tune frequency (Hz)
    type: real
    value: '-130'
  states: {}
- name: analog_phase_modulator_fc_0
  id: analog_phase_modulator_fc
  parameters:
    sensitivity: '-1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-tune'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate/(decim1*decim2)
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: f'beacons_phases_{timestamp}_tune_{tune}_unwrap'
    type: byte
    vlen: '24'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: samples_fifo
    repeat: 'False'
    type: byte
    vlen: '1416'
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '6000'
    type: byte
    vlen: '12'
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '6000'
    type: byte
    vlen: '12'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    type: byte
    vlen: '12'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: '-245 kHz at 600 ksps'
    repeat: 'True'
    type: complex
    vector: np.exp(-1j*2*np.pi*49*np.arange(120)/120)
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    comment: '-1.6 Hz at 6 ksps'
    repeat: 'True'
    type: complex
    vector: np.exp(-1j*2*np.pi*np.arange(3750)/3750)
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '696'
    type: short
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.01'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.005'
    max_dev: '0.01'
    nfilters: nfilt
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '0.5'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.005'
    max_dev: '0.01'
    nfilters: nfilt
    osps: '1'
    pfb_mf_taps: rrc_taps_bpsk
    resamp_type: digital.IR_PFB_MF
    sps: sps_bpsk
    ted_gain: '0.5'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import ceil
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import datetime
  states: {}
- name: linrad_fill_missing_blocks_0
  id: linrad_fill_missing_blocks
  parameters: {}
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '2500'
    decim: decim2
    gain: '1'
    samp_rate: samp_rate/decim1
    type: fir_filter_ccf
    width: samp_rate/(decim1 * decim2) - 2 * 2500
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '2500'
    decim: decim2
    gain: '1'
    samp_rate: samp_rate/decim1
    type: fir_filter_ccf
    width: samp_rate/(decim1 * decim2) - 2 * 2500
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '3000'
    decim: decim1
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/decim1 - 2*3000
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '3000'
    decim: decim1
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/decim1 - 2*3000
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 0,1,1,1
    legend: 'False'
    name: 8APSK constellation
    size: int(0.5*baudrate)
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 0,2,1,1
    legend: 'False'
    name: BPSK constellation
    size: '800'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    alpha2: '1'
    average: '0.2'
    bw: samp_rate/(decim1*decim2)
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,1
    label1: 8APSK beacon
    label2: BPSK beacon
    name: Spectrum
    nconnections: '2'
    type: complex
    ymax: '-20'
    ymin: '-70'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,3
    label1: 8APSK beacon
    label2: BPSK beacon
    name: Beacon phase
    nconnections: '2'
    size: '6000'
    srate: '6000'
    type: float
    ylabel: Phase
    ymax: 2*np.pi
    ymin: '-2*np.pi'
    yunit: rad
  states: {}
- name: satellites_costas_loop_8apsk_cc_0
  id: satellites_costas_loop_8apsk_cc
  parameters:
    loop_bw: '0.0001'
  states: {}
- name: satellites_phase_unwrap_0
  id: satellites_phase_unwrap
  parameters: {}
  states: {}
- name: satellites_phase_unwrap_0_0
  id: satellites_phase_unwrap
  parameters: {}
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1.0'
  states: {}
- name: satellites_rms_agc_0_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1.0'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq_input
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: bpsk_beacon
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: freq_corr
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: offset_corr
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: bpsk_phase
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: apsk_phase
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: iq_input
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: iq_input
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: bpsk_beacon
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: freq_corr
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: freq_corr
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: bpsk_phase
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: apsk_phase
  states: {}
- name: virtual_source_3_1
  id: virtual_source
  parameters:
    stream_id: bpsk_phase
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: offset_corr
  states: {}

connections:
- [analog_phase_modulator_fc_0, '0', blocks_multiply_xx_2, '1']
- [analog_sig_source_x_0, '0', virtual_sink_2, '0']
- [blocks_file_source_0, '0', linrad_fill_missing_blocks_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', virtual_sink_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_streams_to_vector_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_streams_to_vector_0, '1']
- [blocks_multiply_xx_0, '0', low_pass_filter_1, '0']
- [blocks_multiply_xx_1, '0', satellites_rms_agc_0, '0']
- [blocks_multiply_xx_1_0, '0', satellites_rms_agc_0_0, '0']
- [blocks_multiply_xx_2, '0', satellites_costas_loop_8apsk_cc_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_file_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_vector_source_x_1, '0', virtual_sink_2_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [digital_costas_loop_cc_0, '0', digital_symbol_sync_xx_0_0, '0']
- [digital_costas_loop_cc_0, '1', blocks_null_sink_1, '0']
- [digital_costas_loop_cc_0, '2', virtual_sink_3, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0_0, '0', qtgui_const_sink_x_1, '0']
- [linrad_fill_missing_blocks_0, '0', blocks_vector_to_stream_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_1, '0']
- [low_pass_filter_0_0, '0', blocks_multiply_xx_1_0, '0']
- [low_pass_filter_1, '0', low_pass_filter_0, '0']
- [low_pass_filter_1_0, '0', low_pass_filter_0_0, '0']
- [satellites_costas_loop_8apsk_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [satellites_costas_loop_8apsk_cc_0, '1', blocks_null_sink_0, '0']
- [satellites_costas_loop_8apsk_cc_0, '2', virtual_sink_4, '0']
- [satellites_phase_unwrap_0, '0', blocks_keep_one_in_n_0, '0']
- [satellites_phase_unwrap_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [satellites_rms_agc_0, '0', blocks_multiply_xx_2, '0']
- [satellites_rms_agc_0, '0', qtgui_freq_sink_x_0, '0']
- [satellites_rms_agc_0_0, '0', digital_costas_loop_cc_0, '0']
- [satellites_rms_agc_0_0, '0', virtual_sink_1, '0']
- [virtual_source_0, '0', low_pass_filter_1_0, '0']
- [virtual_source_0_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_1, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_2, '0', blocks_multiply_xx_1, '1']
- [virtual_source_2_0, '0', blocks_multiply_xx_1_0, '1']
- [virtual_source_3, '0', qtgui_time_sink_x_0, '1']
- [virtual_source_3, '0', satellites_phase_unwrap_0_0, '0']
- [virtual_source_3_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_3_0, '0', satellites_phase_unwrap_0, '0']
- [virtual_source_3_1, '0', analog_phase_modulator_fc_0, '0']
- [virtual_source_4, '0', blocks_multiply_xx_1, '2']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
