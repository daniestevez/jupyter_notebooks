options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: juice_decoder_beamform_verification
    output_language: python
    run_options: run
    title: JUICE X-band telemetry decoder (with crude beamforming)
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '''''.join([str(i) for i in (syncword+1)//2])[-64:]'
  states: {}
- name: baudrate
  id: variable
  parameters:
    value: '526310.6'
  states: {}
- name: initial_frequency
  id: variable
  parameters:
    value: '-42e3'
  states: {}
- name: max_pll
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: pll_bw
  id: variable
  parameters:
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 6.144e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate / baudrate
  states: {}
- name: syncword
  id: variable
  parameters:
    value: 2*np.unpackbits(np.frombuffer(bytes.fromhex(syncword_hex), dtype = 'uint8')).astype('int')-1
  states: {}
- name: syncword_hex
  id: variable
  parameters:
    value: '''034776C7272895B0FCB88938D8D76A4F'''
  states: {}
- name: basename
  id: parameter
  parameters:
    type: str
    value: /home/daniel/JUICE/JUICE_2023-04-15T05:33:20.040816_0
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: 2**15
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_short_0_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: 2**15
    vector_output: 'False'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '8'
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: beamform_0.c64
    type: short
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: beamform_1.c64
    type: short
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: f'{basename}_0x'
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: f'{basename}_0y'
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: f'{basename}_1y'
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    file: f'{basename}_1x'
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_1
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: pwr_ratio * np.exp(1j*np.deg2rad(phase_diff))
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: pwr_ratio2 * np.exp(1j*np.deg2rad(phase_diff2))
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: np.array([1] * 23359 + [1+1e-6], 'float32')
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: '1'
    type: complex
  states: {}
- name: mmse_resampler_xx_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: '1'
    type: complex
  states: {}
- name: phase_diff
  id: parameter
  parameters:
    type: eng_float
    value: '61.33'
  states: {}
- name: phase_diff2
  id: parameter
  parameters:
    type: eng_float
    value: '-167.64'
  states: {}
- name: pwr_ratio
  id: parameter
  parameters:
    type: eng_float
    value: '0.433'
  states: {}
- name: pwr_ratio2
  id: parameter
  parameters:
    type: eng_float
    value: '0.545'
  states: {}

connections:
- [blocks_add_xx_0, '0', mmse_resampler_xx_0_0, '0']
- [blocks_add_xx_0_0, '0', blocks_delay_0, '0']
- [blocks_complex_to_interleaved_short_0, '0', blocks_file_sink_0_0, '0']
- [blocks_complex_to_interleaved_short_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_delay_0, '0', mmse_resampler_xx_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_interleaved_short_to_complex_0_0_0, '0']
- [blocks_file_source_0_1, '0', blocks_interleaved_short_to_complex_0_1, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_add_xx_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_interleaved_short_to_complex_0_0_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_interleaved_short_to_complex_0_1, '0', blocks_add_xx_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_1_0, '0', blocks_add_xx_0_0, '1']
- [blocks_vector_source_x_0, '0', mmse_resampler_xx_0, '1']
- [mmse_resampler_xx_0, '0', blocks_complex_to_interleaved_short_0_0, '0']
- [mmse_resampler_xx_0_0, '0', blocks_complex_to_interleaved_short_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
