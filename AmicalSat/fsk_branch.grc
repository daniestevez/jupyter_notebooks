options:
  parameters:
    author: Daniel Estevez
    generate_options: hb
    id: fsk_branch
    output_language: python
    title: FSK clock branch
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: delay
    type: complex
  states: {}
- name: blocks_delay_0_1_0
  id: blocks_delay
  parameters:
    delay: delay
    type: complex
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: decimation
  id: parameter
  parameters:
    label: Decimation
    type: intx
    value: '8'
  states: {}
- name: delay
  id: parameter
  parameters:
    label: Delay
    type: intx
    value: '0'
  states: {}
- name: digital_binary_slicer_fb_0_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: decimation
    taps: taps
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0_1
  id: fir_filter_xxx
  parameters:
    decim: '8'
    taps: taps
    type: ccc
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: message
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: symbols
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: low
    type: complex
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: high
    type: complex
  states: {}
- name: satellites_sync_to_pdu_packed_0_0_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '34'
    sync: '"1110011111100111111001111110011111100111"'
    threshold: sync_threshold
  states: {}
- name: sync_threshold
  id: parameter
  parameters:
    label: Syncword threshold
    type: intx
    value: '0'
  states: {}
- name: taps
  id: parameter
  parameters:
    label: Taps
    value: '[0]'
  states: {}

connections:
- [blocks_complex_to_mag_0_0, '0', blocks_sub_xx_0_0, '1']
- [blocks_complex_to_mag_0_0_1, '0', blocks_sub_xx_0_0, '0']
- [blocks_delay_0_1, '0', fir_filter_xxx_0_0, '0']
- [blocks_delay_0_1_0, '0', fir_filter_xxx_0_0_1, '0']
- [blocks_sub_xx_0_0, '0', digital_binary_slicer_fb_0_0_0, '0']
- [blocks_sub_xx_0_0, '0', pad_sink_1, '0']
- [digital_binary_slicer_fb_0_0_0, '0', satellites_sync_to_pdu_packed_0_0_0, '0']
- [fir_filter_xxx_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [fir_filter_xxx_0_0_1, '0', blocks_complex_to_mag_0_0_1, '0']
- [pad_source_0, '0', blocks_delay_0_1, '0']
- [pad_source_0_0, '0', blocks_delay_0_1_0, '0']
- [satellites_sync_to_pdu_packed_0_0_0, out, pad_sink_0, in]

metadata:
  file_format: 1
