options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: nrf24
    output_language: python
    title: NRF24L01+ decoder
  states: {}

blocks:
- name: clock_bw
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '0.4'
  states: {}
- name: clock_damp
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '1.0'
  states: {}
- name: clock_lim
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '0.01'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '5'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/shockburst.u8
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/Descargas/gqrx_20200207_105434_2415300000_7999999_fc_compress8.raw
    offset: int(8 * samp_rate)
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: 8*8*8
    long_form: 'True'
    type: ff
  states: {state: bypassed}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '1110011111100111111001111110011111100111'
    tagname: packet
    threshold: '2'
    type: float
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: clock_damp
    loop_bw: clock_bw
    max_dev: clock_lim
    nfilters: '0'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '8'
    ted_gain: '1.47'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 800e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 50e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    size: '800'
    srate: '1'
    style1: '0'
    tr_delay: '300'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet"'
    type: float
    ymax: '5'
    ymin: '-5'
  states: {}
- name: sync_to_pdu_packed_0
  id: sync_to_pdu_packed
  parameters:
    packlen: '34'
    sync: '"1110011111100111111001111110011111100111"'
    threshold: '2'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', dc_blocker_xx_0, '0']
- [blocks_file_source_0, '0', low_pass_filter_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [dc_blocker_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', sync_to_pdu_packed_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', qtgui_time_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [sync_to_pdu_packed_0, out, blocks_message_debug_0, print_pdu]
- [sync_to_pdu_packed_0, out, blocks_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
