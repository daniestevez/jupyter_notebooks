options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: nrf24
    output_language: python
    title: NRF24L01+ decoder
  states: {}

blocks:
- name: lowpass_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 660e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 33e3
    win: firdes.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000000'
  states: {}
- name: taps
  id: variable
  parameters:
    value: np.ones(8)/8
  states: {}
- name: taps_nrz
  id: variable
  parameters:
    value: np.ones(2)/2
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 160e3/2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/shockburst.u8
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/Descargas/gqrx_20200207_105434_2415300000_7999999_fc_compress8.raw
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '1110011111100111111001111110011111100111'
    tagname: packet
    threshold: '0'
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-55e3'
    decim: '1'
    samp_rate: samp_rate
    taps: lowpass_taps
    type: ccc
  states: {}
- name: fsk_branch_0
  id: fsk_branch
  parameters:
    decimation: '8'
    delay: '0'
    sync_threshold: '0'
    taps: taps
  states: {}
- name: fsk_branch_0_0
  id: fsk_branch
  parameters:
    decimation: '8'
    delay: '2'
    sync_threshold: '0'
    taps: taps
  states: {}
- name: fsk_branch_0_0_0
  id: fsk_branch
  parameters:
    decimation: '8'
    delay: '4'
    sync_threshold: '0'
    taps: taps
  states: {}
- name: fsk_branch_0_0_0_0
  id: fsk_branch
  parameters:
    decimation: '8'
    delay: '8'
    sync_threshold: '0'
    taps: taps
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 3e6
    decim: '1'
    gain: '1'
    samp_rate: 10e6
    type: fir_filter_ccf
    width: 1e6
    win: firdes.WIN_HAMMING
  states: {state: bypassed}
- name: nrz_branch_0
  id: nrz_branch
  parameters:
    decimation: '8'
    delay: '0'
    sync_threshold: '0'
    taps: taps_nrz
  states: {}
- name: nrz_branch_0_0
  id: nrz_branch
  parameters:
    decimation: '8'
    delay: '2'
    sync_threshold: '0'
    taps: taps_nrz
  states: {}
- name: nrz_branch_0_0_0
  id: nrz_branch
  parameters:
    decimation: '8'
    delay: '4'
    sync_threshold: '0'
    taps: taps_nrz
  states: {}
- name: nrz_branch_0_0_0_0
  id: nrz_branch
  parameters:
    decimation: '8'
    delay: '6'
    sync_threshold: '0'
    taps: taps_nrz
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    marker2: '1'
    marker3: '2'
    nconnections: '3'
    size: '800'
    srate: '1'
    style1: '0'
    style2: '0'
    style3: '0'
    tr_delay: '300'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet"'
    type: float
    ymax: '5'
    ymin: '-5'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '8'
    taps: ''
    type: ccc
  states: {state: bypassed}

connections:
- [analog_quadrature_demod_cf_0, '0', nrz_branch_0, '0']
- [analog_quadrature_demod_cf_0, '0', nrz_branch_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', nrz_branch_0_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', nrz_branch_0_0_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_file_source_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', fsk_branch_0, '1']
- [blocks_multiply_conjugate_cc_0, '0', fsk_branch_0_0, '1']
- [blocks_multiply_conjugate_cc_0, '0', fsk_branch_0_0_0, '1']
- [blocks_multiply_conjugate_cc_0, '0', fsk_branch_0_0_0_0, '1']
- [blocks_multiply_xx_0, '0', fsk_branch_0, '0']
- [blocks_multiply_xx_0, '0', fsk_branch_0_0, '0']
- [blocks_multiply_xx_0, '0', fsk_branch_0_0_0, '0']
- [blocks_multiply_xx_0, '0', fsk_branch_0_0_0_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', qtgui_time_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_multiply_xx_0, '0']
- [fsk_branch_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [fsk_branch_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [fsk_branch_0_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [fsk_branch_0_0_0, '0', qtgui_time_sink_x_0, '1']
- [fsk_branch_0_0_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [fsk_branch_0_0_0_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [nrz_branch_0, '0', qtgui_time_sink_x_0, '2']
- [nrz_branch_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [nrz_branch_0_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [nrz_branch_0_0_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [nrz_branch_0_0_0_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [rational_resampler_xxx_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
