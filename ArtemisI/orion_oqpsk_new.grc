options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: orion_oqpsk_new
    output_language: python
    title: Orion OQPSK demodulator
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '''''.join([str(i) for i in (syncword+1)//2])'
  states: {}
- name: baudrate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4500000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/baudrate
  states: {}
- name: sync_threshold
  id: variable
  parameters:
    value: '8'
  states: {}
- name: syncword
  id: variable
  parameters:
    value: 2*np.unpackbits(np.frombuffer(bytes.fromhex(syncword_hex), dtype = 'uint8')).astype('int')-1
  states: {}
- name: syncword_hex
  id: variable
  parameters:
    value: '''034776C7272895B0'''
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '2'
    type: float
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: new/orion_2022_12_08_15_46_46_soft_pdus.f32
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/contracting/camras/new/camras-2022_12_08_15_46_46_2216.500MHz_4.5Msps_ci16_le.sigmf-data
    repeat: 'False'
    type: short
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_interleave_0_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-2 * np.pi * 5e3 / samp_rate'
  states: {}
- name: digital_costas_loop_cc_0_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '1e-4'
  states: {}
- name: digital_symbol_sync_xx_0_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '1e-3'
    max_dev: '0.001'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '4'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: dslwp_ccsds_pseudo_randomizer_0
  id: dslwp_ccsds_pseudo_randomizer
  parameters:
    data_format: '3'
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1/4]*4'
    type: ccc
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: syncword[::-1]/syncword.size
    type: fff
  states: {}
- name: fir_filter_xxx_1_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: syncword[::-1]/syncword.size
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: float
  states: {}
- name: pfb_arb_resampler_xxx_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 4 / sps
    type: ccf
  states: {}
- name: phase_difference
  id: parameter
  parameters:
    type: eng_float
    value: '-14.3'
  states: {}
- name: power_ratio
  id: parameter
  parameters:
    type: eng_float
    value: '0.45'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '1'
    gui_hint: 0,1,1,1
    name: OQPSK constellation
    size: '10000'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: 0,0,1,1
    label1: Signal polarization
    name: '"Signal PSD"'
    type: complex
    ymax: '-75'
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: 4 * samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: 1,1,1,1
    label1: Signal polarization
    name: '"Signal suppressed carrier"'
    type: complex
    ymax: '-170'
    ymin: '-220'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,1
    label1: Symbols (branch 0)
    label2: ASM correlation (branch 0)
    label3: ASM correlation (branch 1)
    marker1: '0'
    name: ASM correlation
    nconnections: '3'
    size: (2048+64)*10
    srate: baudrate
    style1: '0'
    tr_chan: '1'
    tr_delay: '1e-4'
    tr_level: '-0.8'
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}
- name: satellites_rms_agc_0_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-5'
    reference: '1.0'
  states: {}
- name: satellites_sync_to_pdu_soft_0
  id: satellites_sync_to_pdu_soft
  parameters:
    packlen: '2048'
    sync: access_code
    threshold: sync_threshold
  states: {}
- name: satellites_sync_to_pdu_soft_0_0
  id: satellites_sync_to_pdu_soft
  parameters:
    packlen: '2048'
    sync: access_code
    threshold: sync_threshold
  states: {}
- name: satellites_sync_to_pdu_soft_0_0_0
  id: satellites_sync_to_pdu_soft
  parameters:
    packlen: '2048'
    sync: access_code
    threshold: sync_threshold
  states: {}
- name: satellites_sync_to_pdu_soft_0_1
  id: satellites_sync_to_pdu_soft
  parameters:
    packlen: '2048'
    sync: access_code
    threshold: sync_threshold
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_interleave_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_complex_to_float_0, '1', blocks_delay_0, '0']
- [blocks_complex_to_float_0, '1', blocks_interleave_0, '1']
- [blocks_complex_to_float_0_0, '0', blocks_delay_0_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_float_to_complex_0_0, '1']
- [blocks_delay_0, '0', blocks_interleave_0_0, '0']
- [blocks_delay_0_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_float_to_complex_0_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_interleave_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_interleave_0, '0', fir_filter_xxx_1, '0']
- [blocks_interleave_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_interleave_0, '0', satellites_sync_to_pdu_soft_0, '0']
- [blocks_interleave_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_interleave_0_0, '0', fir_filter_xxx_1_0, '0']
- [blocks_interleave_0_0, '0', satellites_sync_to_pdu_soft_0_1, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_rotator_cc_0, '0']
- [blocks_multiply_const_vxx_0, '0', satellites_sync_to_pdu_soft_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', satellites_sync_to_pdu_soft_0_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_interleave_0_0, '1']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_rotator_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_rotator_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_rotator_cc_0, '0', blocks_multiply_xx_0, '2']
- [blocks_rotator_cc_0, '0', blocks_multiply_xx_0, '3']
- [blocks_rotator_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_rotator_cc_0, '0', satellites_rms_agc_0_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', blocks_complex_to_float_0_0, '0']
- [digital_symbol_sync_xx_0_0_0, '0', blocks_complex_to_float_0, '0']
- [digital_symbol_sync_xx_0_0_0, '0', qtgui_const_sink_x_0, '0']
- [dslwp_ccsds_pseudo_randomizer_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [fir_filter_xxx_0_0, '0', digital_symbol_sync_xx_0_0_0, '0']
- [fir_filter_xxx_1, '0', qtgui_time_sink_x_0, '1']
- [fir_filter_xxx_1_0, '0', qtgui_time_sink_x_0, '2']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_1, '0']
- [pfb_arb_resampler_xxx_0_0, '0', digital_costas_loop_cc_0_0_0, '0']
- [satellites_rms_agc_0_0, '0', pfb_arb_resampler_xxx_0_0, '0']
- [satellites_sync_to_pdu_soft_0, out, dslwp_ccsds_pseudo_randomizer_0, in]
- [satellites_sync_to_pdu_soft_0_0, out, dslwp_ccsds_pseudo_randomizer_0, in]
- [satellites_sync_to_pdu_soft_0_0_0, out, dslwp_ccsds_pseudo_randomizer_0, in]
- [satellites_sync_to_pdu_soft_0_1, out, dslwp_ccsds_pseudo_randomizer_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.5.0
