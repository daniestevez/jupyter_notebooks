options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: argomoon_nrz
    output_language: python
    run_options: run
    title: ArgoMoon NRZ decoder
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '''''.join([str(i) for i in (syncword+1)//2])[-64:]'
  states: {}
- name: baudrate
  id: variable
  parameters:
    value: '31969'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: integ
  id: variable
  parameters:
    value: round(5*samp_rate/(nfft*decim))
  states: {}
- name: nfft
  id: variable
  parameters:
    value: 2**12
  states: {}
- name: pll_bw
  id: variable
  parameters:
    value: '2.5'
  states: {}
- name: pll_range
  id: variable
  parameters:
    value: '200'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate / (baudrate * decim)
  states: {}
- name: subcarrier
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: syncword
  id: variable
  parameters:
    value: 2*np.unpackbits(np.frombuffer(bytes.fromhex(syncword_hex), dtype = 'uint8')).astype('int')-1
  states: {}
- name: syncword_hex
  id: variable
  parameters:
    value: '''034776C7272895B0'''
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '10'
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: 2*np.pi*pll_range*decim/samp_rate
    min_freq: '-2*np.pi*pll_range*decim/samp_rate'
    w: 2*np.pi*pll_bw*decim/samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-doppler_difference'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate/100
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters:
    vlen: nfft
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_complex_to_mag_squared_0_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_complex_to_mag_squared_0_1_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: delay
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: argomoon_frames_nrz.u8
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: Argomoon_2022-11-16T16:47:23_1ax.sigmf-data
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: Argomoon_2022-11-16T16:47:23_5cx.sigmf-data
    repeat: 'False'
    type: short
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: integ
    type: float
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: integ
    type: float
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0_0_0
  id: blocks_integrate_xx
  parameters:
    decim: integ
    type: float
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0_1
  id: blocks_integrate_xx
  parameters:
    decim: integ*2
    type: complex
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0_2
  id: blocks_integrate_xx
  parameters:
    decim: integ
    type: float
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0_2_0
  id: blocks_integrate_xx
  parameters:
    decim: integ
    type: float
    vlen: nfft
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_multiply_conjugate_cc_1
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: nfft
  states: {}
- name: blocks_multiply_const_vxx_2_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: power_ratio * np.exp(1j * np.deg2rad(phase_difference))
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: nfft
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: nfft
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: nfft
  states: {}
- name: blocks_nlog10_ff_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: nfft
  states: {}
- name: blocks_nlog10_ff_0_1_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: nfft
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '100'
    type: float
    vlen: nfft
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: '100'
    type: float
    vlen: nfft
  states: {}
- name: blocks_repeat_0_1
  id: blocks_repeat
  parameters:
    interp: '100'
    type: float
    vlen: nfft
  states: {}
- name: blocks_repeat_0_1_0
  id: blocks_repeat
  parameters:
    interp: '100'
    type: float
    vlen: nfft
  states: {}
- name: blocks_repeat_0_2
  id: blocks_repeat
  parameters:
    interp: '100'
    type: complex
  states: {}
- name: blocks_repeat_0_3
  id: blocks_repeat
  parameters:
    interp: '100'
    type: float
    vlen: nfft
  states: {}
- name: blocks_repeat_0_3_0
  id: blocks_repeat
  parameters:
    interp: '100'
    type: float
    vlen: nfft
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: float
  states: {}
- name: blocks_stream_to_vector_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate * 10
    type: complex
  states: {}
- name: delay
  id: parameter
  parameters:
    type: intx
    value: '3'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.001'
    max_dev: '0.01'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: doppler_difference
  id: parameter
  parameters:
    type: eng_float
    value: '-0.418+40e-3'
  states: {}
- name: dslwp_ccsds_pseudo_randomizer_0
  id: dslwp_ccsds_pseudo_randomizer
  parameters:
    data_format: '3'
  states: {}
- name: dslwp_ccsds_pseudo_randomizer_0_0
  id: dslwp_ccsds_pseudo_randomizer
  parameters:
    data_format: '3'
  states: {state: disabled}
- name: dslwp_ccsds_pseudo_randomizer_0_0_0
  id: dslwp_ccsds_pseudo_randomizer
  parameters:
    data_format: '3'
  states: {state: disabled}
- name: dslwp_ccsds_pseudo_randomizer_0_0_1
  id: dslwp_ccsds_pseudo_randomizer
  parameters:
    data_format: '3'
  states: {state: disabled}
- name: dslwp_ccsds_pseudo_randomizer_0_1
  id: dslwp_ccsds_pseudo_randomizer
  parameters:
    data_format: '3'
  states: {state: disabled}
- name: dslwp_ccsds_pseudo_randomizer_0_2
  id: dslwp_ccsds_pseudo_randomizer
  parameters:
    data_format: '3'
  states: {state: disabled}
- name: dslwp_ccsds_pseudo_randomizer_0_3
  id: dslwp_ccsds_pseudo_randomizer
  parameters:
    data_format: '3'
  states: {state: disabled}
- name: dslwp_ccsds_turbo_decode_0
  id: dslwp_ccsds_turbo_decode
  parameters:
    base: '223'
    code_type: '2'
    iterations: '20'
    octets: '5'
    sigma: '1.0'
    update_sigma: '1'
  states: {}
- name: dslwp_ccsds_turbo_decode_0_0
  id: dslwp_ccsds_turbo_decode
  parameters:
    base: '223'
    code_type: '2'
    iterations: '20'
    octets: '5'
    sigma: '1.0'
    update_sigma: '1'
  states: {state: disabled}
- name: dslwp_ccsds_turbo_decode_0_0_0
  id: dslwp_ccsds_turbo_decode
  parameters:
    base: '223'
    code_type: '2'
    iterations: '20'
    octets: '5'
    sigma: '1.0'
    update_sigma: '1'
  states: {state: disabled}
- name: dslwp_ccsds_turbo_decode_0_0_1
  id: dslwp_ccsds_turbo_decode
  parameters:
    base: '223'
    code_type: '2'
    iterations: '20'
    octets: '5'
    sigma: '1.0'
    update_sigma: '1'
  states: {state: disabled}
- name: dslwp_ccsds_turbo_decode_0_1
  id: dslwp_ccsds_turbo_decode
  parameters:
    base: '223'
    code_type: '2'
    iterations: '20'
    octets: '5'
    sigma: '1.0'
    update_sigma: '1'
  states: {state: disabled}
- name: dslwp_ccsds_turbo_decode_0_2
  id: dslwp_ccsds_turbo_decode
  parameters:
    base: '223'
    code_type: '2'
    iterations: '20'
    octets: '5'
    sigma: '1.0'
    update_sigma: '1'
  states: {state: disabled}
- name: dslwp_ccsds_turbo_decode_0_3
  id: dslwp_ccsds_turbo_decode
  parameters:
    base: '223'
    code_type: '2'
    iterations: '20'
    octets: '5'
    sigma: '1.0'
    update_sigma: '1'
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: float
    window: '[]'
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: float
    window: '[]'
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: fft_vxx_0_1_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: round(sps)
    taps: '[2e3/round(sps)]*round(sps)'
    type: fff
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: round(sps)
    samp_delay: '2'
    taps: '[2e3/round(sps)]*round(sps)'
    type: fff
  states: {}
- name: fir_filter_xxx_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: round(sps)
    samp_delay: '4'
    taps: '[2e3/round(sps)]*round(sps)'
    type: fff
  states: {}
- name: fir_filter_xxx_0_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: round(sps)
    samp_delay: '5'
    taps: '[2e3/round(sps)]*round(sps)'
    type: fff
  states: {}
- name: fir_filter_xxx_0_0_1
  id: fir_filter_xxx
  parameters:
    decim: round(sps)
    samp_delay: '3'
    taps: '[2e3/round(sps)]*round(sps)'
    type: fff
  states: {}
- name: fir_filter_xxx_0_1
  id: fir_filter_xxx
  parameters:
    decim: round(sps)
    samp_delay: '1'
    taps: '[2e3/round(sps)]*round(sps)'
    type: fff
  states: {}
- name: fir_filter_xxx_0_2
  id: fir_filter_xxx
  parameters:
    decim: round(sps)
    taps: '[2e3/round(sps)]*round(sps)'
    type: fff
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: syncword[::-1]/syncword.size
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-64.313e3'
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, 1, 0.5/decim, 0.1/decim)
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-64.313e3'
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, 1, 0.5/decim, 0.1/decim)
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: round(sps)/sps * (1+2e-6)
    type: fff
  states: {}
- name: phase_difference
  id: parameter
  parameters:
    type: eng_float
    value: '180'
  states: {}
- name: power_ratio
  id: parameter
  parameters:
    type: eng_float
    value: '0.4'
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    gui_hint: 1,0,1,1
    size: baudrate
    type: float
    xmax: '3'
    xmin: '-3'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,1,1,1
    marker1: '0'
    nconnections: '2'
    size: (17848+32*2) * 3
    srate: baudrate
    style1: '0'
    tr_chan: '1'
    tr_delay: '1e-4'
    tr_level: '-0.8'
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    gui_hint: 0,0,1,1
    label1: Antenna 1ay
    label2: Antenna 5cy
    label3: Beamformed
    label4: PLL output I
    label5: PLL output Q
    nconnections: '5'
    vlen: nfft
    x_axis_label: '"Frequency (Hz)"'
    x_start: '-0.5*samp_rate/decim'
    x_step: samp_rate/(decim*nfft)
    x_units: '"Hz"'
    y_axis_label: '"PSD (dB)"'
    y_units: '"dB"'
    ymax: '20'
    ymin: '-5'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    gui_hint: 0,1,1,1
    name: '"Cross-correlation phase"'
    vlen: nfft
    x_axis_label: '"Frequency (Hz)"'
    x_start: '-0.5*samp_rate/decim'
    x_step: samp_rate/(decim*nfft)
    x_units: '"Hz"'
    y_axis_label: '"Phase (rad)"'
    y_units: '"rad"'
    ymax: '5'
    ymin: '-5'
  states: {}
- name: satellites_crc_check_0
  id: satellites_crc_check
  parameters:
    discard_crc: 'True'
    final_xor: '0x0'
    initial_value: '0xFFFF'
    input_reflected: 'False'
    num_bits: '16'
    poly: '0x1021'
    result_reflected: 'False'
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_sync_to_pdu_soft_0
  id: satellites_sync_to_pdu_soft
  parameters:
    packlen: '17848'
    sync: access_code
    threshold: threshold
  states: {}
- name: satellites_sync_to_pdu_soft_0_0
  id: satellites_sync_to_pdu_soft
  parameters:
    packlen: '17848'
    sync: access_code
    threshold: threshold
  states: {}
- name: satellites_sync_to_pdu_soft_0_1
  id: satellites_sync_to_pdu_soft
  parameters:
    packlen: '17848'
    sync: access_code
    threshold: threshold
  states: {}
- name: satellites_sync_to_pdu_soft_0_1_0
  id: satellites_sync_to_pdu_soft
  parameters:
    packlen: '17848'
    sync: access_code
    threshold: threshold
  states: {}
- name: satellites_sync_to_pdu_soft_0_1_1
  id: satellites_sync_to_pdu_soft
  parameters:
    packlen: '17848'
    sync: access_code
    threshold: threshold
  states: {}
- name: satellites_sync_to_pdu_soft_0_2
  id: satellites_sync_to_pdu_soft
  parameters:
    packlen: '17848'
    sync: access_code
    threshold: threshold
  states: {}
- name: satellites_sync_to_pdu_soft_0_3
  id: satellites_sync_to_pdu_soft
  parameters:
    packlen: '17848'
    sync: access_code
    threshold: threshold
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: ch0
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: ch1
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: beamform
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: pll_re
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: pll_im
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: crosscorr_phase
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: beamform
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: ch0
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: ch1
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: beamform
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: crosscorr_phase
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: pll_re
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: pll_im
  states: {}
- name: virtual_source_3_0_0
  id: virtual_source
  parameters:
    stream_id: pll_im
  states: {}

connections:
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_float_0, '0']
- [analog_sig_source_x_0, '0', blocks_repeat_0_2, '0']
- [blocks_add_xx_0, '0', virtual_sink_0_0_0, '0']
- [blocks_complex_to_arg_0, '0', virtual_sink_2, '0']
- [blocks_complex_to_float_0, '0', virtual_sink_1, '0']
- [blocks_complex_to_float_0, '1', virtual_sink_1_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0, '0', blocks_integrate_xx_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_1, '0', blocks_integrate_xx_0_2, '0']
- [blocks_complex_to_mag_squared_0_1_0, '0', blocks_integrate_xx_0_2_0, '0']
- [blocks_delay_0_0, '0', blocks_multiply_const_vxx_2_0_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0_0, '0']
- [blocks_integrate_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_integrate_xx_0_0_0, '0', blocks_nlog10_ff_0_0_0, '0']
- [blocks_integrate_xx_0_1, '0', blocks_complex_to_arg_0, '0']
- [blocks_integrate_xx_0_2, '0', blocks_nlog10_ff_0_1, '0']
- [blocks_integrate_xx_0_2_0, '0', blocks_nlog10_ff_0_1_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', blocks_delay_0_0, '0']
- [blocks_multiply_conjugate_cc_1, '0', blocks_integrate_xx_0_1, '0']
- [blocks_multiply_const_vxx_2_0_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_xx_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_repeat_0, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_repeat_0_0, '0']
- [blocks_nlog10_ff_0_0_0, '0', blocks_repeat_0_1, '0']
- [blocks_nlog10_ff_0_1, '0', blocks_repeat_0_3, '0']
- [blocks_nlog10_ff_0_1_0, '0', blocks_repeat_0_3_0, '0']
- [blocks_repeat_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_repeat_0_0, '0', qtgui_vector_sink_f_0, '3']
- [blocks_repeat_0_1, '0', qtgui_vector_sink_f_0, '4']
- [blocks_repeat_0_1_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_repeat_0_2, '0', blocks_multiply_xx_0, '1']
- [blocks_repeat_0_3, '0', qtgui_vector_sink_f_0, '1']
- [blocks_repeat_0_3_0, '0', qtgui_vector_sink_f_0, '2']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_1, '0']
- [blocks_stream_to_vector_0_0_0, '0', fft_vxx_0_1_0, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_1_0, '0', fft_vxx_0_0_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_histogram_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', satellites_sync_to_pdu_soft_0_0, '0']
- [dslwp_ccsds_pseudo_randomizer_0, out, dslwp_ccsds_turbo_decode_0, in]
- [dslwp_ccsds_pseudo_randomizer_0_0, out, dslwp_ccsds_turbo_decode_0_0, in]
- [dslwp_ccsds_pseudo_randomizer_0_0_0, out, dslwp_ccsds_turbo_decode_0_0_0, in]
- [dslwp_ccsds_pseudo_randomizer_0_0_1, out, dslwp_ccsds_turbo_decode_0_0_1, in]
- [dslwp_ccsds_pseudo_randomizer_0_1, out, dslwp_ccsds_turbo_decode_0_1, in]
- [dslwp_ccsds_pseudo_randomizer_0_2, out, dslwp_ccsds_turbo_decode_0_2, in]
- [dslwp_ccsds_pseudo_randomizer_0_3, out, dslwp_ccsds_turbo_decode_0_3, in]
- [dslwp_ccsds_turbo_decode_0, out, satellites_crc_check_0, in]
- [dslwp_ccsds_turbo_decode_0_0, out, satellites_crc_check_0, in]
- [dslwp_ccsds_turbo_decode_0_0_0, out, satellites_crc_check_0, in]
- [dslwp_ccsds_turbo_decode_0_0_1, out, satellites_crc_check_0, in]
- [dslwp_ccsds_turbo_decode_0_1, out, satellites_crc_check_0, in]
- [dslwp_ccsds_turbo_decode_0_2, out, satellites_crc_check_0, in]
- [dslwp_ccsds_turbo_decode_0_3, out, satellites_crc_check_0, in]
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_1, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [fft_vxx_0_0_0, '0', blocks_complex_to_mag_squared_0_0_0, '0']
- [fft_vxx_0_1, '0', blocks_complex_to_mag_squared_0_1, '0']
- [fft_vxx_0_1, '0', blocks_multiply_conjugate_cc_1, '1']
- [fft_vxx_0_1_0, '0', blocks_complex_to_mag_squared_0_1_0, '0']
- [fir_filter_xxx_0, '0', fir_filter_xxx_1, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [fir_filter_xxx_0, '0', satellites_sync_to_pdu_soft_0, '0']
- [fir_filter_xxx_0_0, '0', satellites_sync_to_pdu_soft_0_1, '0']
- [fir_filter_xxx_0_0_0, '0', satellites_sync_to_pdu_soft_0_2, '0']
- [fir_filter_xxx_0_0_0_0, '0', satellites_sync_to_pdu_soft_0_1_1, '0']
- [fir_filter_xxx_0_0_1, '0', satellites_sync_to_pdu_soft_0_1_0, '0']
- [fir_filter_xxx_0_1, '0', satellites_sync_to_pdu_soft_0_3, '0']
- [fir_filter_xxx_0_2, '0', digital_symbol_sync_xx_0, '0']
- [fir_filter_xxx_1, '0', qtgui_time_sink_x_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_add_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', virtual_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_add_xx_0, '1']
- [freq_xlating_fir_filter_xxx_0_0, '0', virtual_sink_0_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [pfb_arb_resampler_xxx_0, '0', fir_filter_xxx_0, '0']
- [pfb_arb_resampler_xxx_0, '0', fir_filter_xxx_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', fir_filter_xxx_0_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', fir_filter_xxx_0_0_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', fir_filter_xxx_0_0_1, '0']
- [pfb_arb_resampler_xxx_0, '0', fir_filter_xxx_0_1, '0']
- [satellites_crc_check_0, ok, pdu_pdu_to_tagged_stream_0, pdus]
- [satellites_crc_check_0, ok, satellites_hexdump_sink_0, in]
- [satellites_sync_to_pdu_soft_0, out, dslwp_ccsds_pseudo_randomizer_0, in]
- [satellites_sync_to_pdu_soft_0_0, out, dslwp_ccsds_pseudo_randomizer_0, in]
- [satellites_sync_to_pdu_soft_0_0, out, dslwp_ccsds_pseudo_randomizer_0_3, in]
- [satellites_sync_to_pdu_soft_0_1, out, dslwp_ccsds_pseudo_randomizer_0, in]
- [satellites_sync_to_pdu_soft_0_1, out, dslwp_ccsds_pseudo_randomizer_0_0, in]
- [satellites_sync_to_pdu_soft_0_1_0, out, dslwp_ccsds_pseudo_randomizer_0, in]
- [satellites_sync_to_pdu_soft_0_1_0, out, dslwp_ccsds_pseudo_randomizer_0_0_0, in]
- [satellites_sync_to_pdu_soft_0_1_1, out, dslwp_ccsds_pseudo_randomizer_0, in]
- [satellites_sync_to_pdu_soft_0_1_1, out, dslwp_ccsds_pseudo_randomizer_0_0_1, in]
- [satellites_sync_to_pdu_soft_0_2, out, dslwp_ccsds_pseudo_randomizer_0, in]
- [satellites_sync_to_pdu_soft_0_2, out, dslwp_ccsds_pseudo_randomizer_0_1, in]
- [satellites_sync_to_pdu_soft_0_3, out, dslwp_ccsds_pseudo_randomizer_0, in]
- [satellites_sync_to_pdu_soft_0_3, out, dslwp_ccsds_pseudo_randomizer_0_2, in]
- [virtual_source_0, '0', analog_pll_carriertracking_cc_0, '0']
- [virtual_source_1, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_1_0, '0', blocks_stream_to_vector_0_0, '0']
- [virtual_source_1_0_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [virtual_source_2, '0', blocks_repeat_0_1_0, '0']
- [virtual_source_3, '0', blocks_stream_to_vector_1, '0']
- [virtual_source_3_0, '0', blocks_stream_to_vector_1_0, '0']
- [virtual_source_3_0_0, '0', fir_filter_xxx_0_2, '0']
- [virtual_source_3_0_0, '0', pfb_arb_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
