options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: orion_oqpsk
    output_language: python
    run_options: run
    title: Orion OQPSK demodulator
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '''''.join([str(i) for i in (syncword+1)//2])'
  states: {}
- name: baudrate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10240000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/baudrate
  states: {}
- name: sync_threshold
  id: variable
  parameters:
    value: '8'
  states: {}
- name: syncword
  id: variable
  parameters:
    value: 2*np.unpackbits(np.frombuffer(bytes.fromhex(syncword_hex), dtype = 'uint8')).astype('int')-1
  states: {}
- name: syncword_hex
  id: variable
  parameters:
    value: '''034776C7272895B0'''
  states: {}
- name: basename
  id: parameter
  parameters:
    label: Base name for the input/output files (includes the antenna but not the polarization)
    type: str
    value: /home/daniel/Artemis1/Orion_2022-11-16T14:14:09.425062_0
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '2'
    type: float
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: f'{basename}_soft_pdus.f32'
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: f'{basename}x'
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: f'{basename}y'
    repeat: 'False'
    type: short
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_interleave_0_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_costas_loop_cc_0_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '1e-4'
  states: {}
- name: digital_symbol_sync_xx_0_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '1e-3'
    max_dev: '0.001'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '4'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: doppler
  id: parameter
  parameters:
    label: Doppler (Hz)
    type: eng_float
    value: '-19e3'
  states: {}
- name: dslwp_ccsds_pseudo_randomizer_0
  id: dslwp_ccsds_pseudo_randomizer
  parameters:
    data_format: '3'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Auto-polarization
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Auto-polarization"""

          def __init__(self, fft_size=1024, fft_avg=1,
                           iir_weight = 1e-2): # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Auto-polarization',   # will show up in GRC
                  in_sig=[np.complex64]*2,
                  out_sig=[np.complex64]*2
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.fft_size = fft_size
              self.fft_avg = fft_avg
              self.set_output_multiple(fft_size * fft_avg)
              self.iir_weight = iir_weight
              self.noise_ampl = np.ones(2)
              self.sig_ampl = np.ones(2)
              self.phase = 0

          def work(self, input_items, output_items):
              x = np.array([inp.reshape((-1, self.fft_avg, self.fft_size))
                                for inp in input_items])
              # axes for x are:
              # (channel: 2, block, fft_num: fft_avg, fft_bin: fft_size)

              fx = np.fft.fft(x)
              fx_sq_avg = np.average(np.abs(fx)**2, axis = 2)
              noise_ampl = np.sqrt(np.median(fx_sq_avg, axis = 2))

              fx_sq_avg_ch_max = np.max(fx_sq_avg/noise_ampl[...,np.newaxis]**2, axis = 0)
              peak_idx = np.argmax(fx_sq_avg_ch_max, axis = 1)

              f_cross = np.average(fx[0] * np.conjugate(fx[1]), axis = 1)
              phase = np.angle(f_cross[np.arange(f_cross.shape[0]),
                                           peak_idx])
              sig_ampl = fx_sq_avg[:,np.arange(fx_sq_avg.shape[1]),peak_idx] #- noise_ampl
              sig_ampl = np.sqrt(np.clip(sig_ampl, 0, np.inf))

              # update IIR filters
              for j in range(x.shape[1]):
                  noise_ampl[:,j] = (1-self.iir_weight)*self.noise_ampl \
                    + self.iir_weight*noise_ampl[:,j]
                  self.noise_ampl = noise_ampl[:,j]
                  sig_ampl[:,j] = (1-self.iir_weight)*self.sig_ampl \
                    + self.iir_weight*sig_ampl[:,j]
                  self.sig_ampl = sig_ampl[:,j]
                  phase_diff = phase[j] - self.phase
                  phase_diff = (phase_diff + np.pi) % (2*np.pi) - np.pi
                  phase[j] = self.phase + self.iir_weight*phase_diff
                  self.phase = (phase[j] + np.pi) % (2*np.pi) - np.pi

              tau = np.log10(sig_ampl[0]/noise_ampl[0]+1e-6) \
                - np.log10(sig_ampl[1]/noise_ampl[1]+1e-6)
              tau = 20*tau/6*0.5 + 0.5
              tau = np.clip(tau, 0, 1)
              # note tau = 1 if sig[0] is 6dB stronger than sig[1] and
              # tau = 0 if sig[0] is 6dB weaker than sig[1]
              a_phase = (tau - 1) * phase
              b_phase = tau * phase
              # note -a_phase + b_phase = phase
              
              alpha = (np.exp(1j*a_phase) * sig_ampl[0] / noise_ampl[0])[:,np.newaxis]
              beta = (np.exp(1j*b_phase) * sig_ampl[1] / noise_ampl[1])[:,np.newaxis]

              y = x.reshape((x.shape[0], x.shape[1], self.fft_avg * self.fft_size))
              y = y / noise_ampl[...,np.newaxis] * np.sqrt(self.fft_size)
              output_items[0][:] = (alpha * y[0] + beta * y[1]).ravel()
              output_items[1][:] = (np.conjugate(beta) * y[0] - np.conjugate(alpha) * y[1]).ravel()
              return len(output_items[0])
    fft_avg: int(0.1*samp_rate/2048)
    fft_size: '2048'
    iir_weight: '0.1'
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1/4]*4'
    type: ccc
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: syncword[::-1]/syncword.size
    type: fff
  states: {}
- name: fir_filter_xxx_1_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: syncword[::-1]/syncword.size
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: doppler
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 2e6, 125e3)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: float
  states: {}
- name: pfb_arb_resampler_xxx_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 4 / sps
    type: ccf
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '1'
    gui_hint: 0,1,1,1
    name: OQPSK constellation
    size: '10000'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: 0,0,1,1
    label1: Signal polarization
    label2: Cross-polarization
    name: '"Signal PSD (after auto-polarization)"'
    nconnections: '2'
    type: complex
    ymax: '-15'
    ymin: '-40'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: 4 * samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: 1,1,1,1
    label1: Signal polarization
    name: '"Signal suppressed carrier"'
    type: complex
    ymax: '70'
    ymin: '20'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,1
    label1: Symbols (branch 0)
    label2: ASM correlation (branch 0)
    label3: ASM correlation (branch 1)
    marker1: '0'
    name: ASM correlation
    nconnections: '3'
    size: (2048+64)*10
    srate: baudrate
    style1: '0'
    tr_chan: '1'
    tr_delay: '1e-4'
    tr_level: '-0.8'
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}
- name: satellites_rms_agc_0_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-5'
    reference: '1.0'
  states: {}
- name: satellites_sync_to_pdu_soft_0
  id: satellites_sync_to_pdu_soft
  parameters:
    packlen: '2048'
    sync: access_code
    threshold: sync_threshold
  states: {}
- name: satellites_sync_to_pdu_soft_0_0
  id: satellites_sync_to_pdu_soft
  parameters:
    packlen: '2048'
    sync: access_code
    threshold: sync_threshold
  states: {}
- name: satellites_sync_to_pdu_soft_0_0_0
  id: satellites_sync_to_pdu_soft
  parameters:
    packlen: '2048'
    sync: access_code
    threshold: sync_threshold
  states: {}
- name: satellites_sync_to_pdu_soft_0_1
  id: satellites_sync_to_pdu_soft
  parameters:
    packlen: '2048'
    sync: access_code
    threshold: sync_threshold
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_interleave_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_complex_to_float_0, '1', blocks_delay_0, '0']
- [blocks_complex_to_float_0, '1', blocks_interleave_0, '1']
- [blocks_complex_to_float_0_0, '0', blocks_delay_0_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_float_to_complex_0_0, '1']
- [blocks_delay_0, '0', blocks_interleave_0_0, '0']
- [blocks_delay_0_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0_0, '0']
- [blocks_float_to_complex_0_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_interleave_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_interleave_0, '0', fir_filter_xxx_1, '0']
- [blocks_interleave_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_interleave_0, '0', satellites_sync_to_pdu_soft_0, '0']
- [blocks_interleave_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_interleave_0_0, '0', fir_filter_xxx_1_0, '0']
- [blocks_interleave_0_0, '0', satellites_sync_to_pdu_soft_0_1, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', epy_block_0, '1']
- [blocks_multiply_const_vxx_0, '0', satellites_sync_to_pdu_soft_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', satellites_sync_to_pdu_soft_0_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_interleave_0_0, '1']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_throttle_0, '0', epy_block_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', blocks_complex_to_float_0_0, '0']
- [digital_symbol_sync_xx_0_0_0, '0', blocks_complex_to_float_0, '0']
- [digital_symbol_sync_xx_0_0_0, '0', qtgui_const_sink_x_0, '0']
- [dslwp_ccsds_pseudo_randomizer_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [epy_block_0, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_0, '1', blocks_null_sink_0, '0']
- [epy_block_0, '1', qtgui_freq_sink_x_0, '1']
- [fir_filter_xxx_0_0, '0', digital_symbol_sync_xx_0_0_0, '0']
- [fir_filter_xxx_1, '0', qtgui_time_sink_x_0, '1']
- [fir_filter_xxx_1_0, '0', qtgui_time_sink_x_0, '2']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_multiply_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_multiply_xx_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_multiply_xx_0, '2']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_multiply_xx_0, '3']
- [freq_xlating_fir_filter_xxx_0, '0', satellites_rms_agc_0_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_1, '0']
- [pfb_arb_resampler_xxx_0_0, '0', digital_costas_loop_cc_0_0_0, '0']
- [satellites_rms_agc_0_0, '0', pfb_arb_resampler_xxx_0_0, '0']
- [satellites_sync_to_pdu_soft_0, out, dslwp_ccsds_pseudo_randomizer_0, in]
- [satellites_sync_to_pdu_soft_0_0, out, dslwp_ccsds_pseudo_randomizer_0, in]
- [satellites_sync_to_pdu_soft_0_0_0, out, dslwp_ccsds_pseudo_randomizer_0, in]
- [satellites_sync_to_pdu_soft_0_1, out, dslwp_ccsds_pseudo_randomizer_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.4.0
