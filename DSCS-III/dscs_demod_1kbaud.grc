options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: dscs_demod_1kbaud
    output_language: python
    title: DSCS-III 1kbaud beacon demodulator
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: bits_1kbaud.f32
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: bypassed}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/daniel/Descargas/gqrx_20200615_023735_1604767900.wav
    repeat: 'False'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.03'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.001'
    max_dev: '0.1'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: '4.8'
    ted_gain: '1.47'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '1600'
    decim: '10'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 1000, 200)
    type: fcf
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1.0'
  states: {}

connections:
- [blocks_complex_to_real_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', satellites_rms_agc_0, '0']
- [satellites_rms_agc_0, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
