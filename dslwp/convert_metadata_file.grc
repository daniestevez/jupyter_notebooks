options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: convert_metadata_file
    output_language: python
    run_options: run
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '40000'
  states: {}
- name: blocks_file_meta_source_0
  id: blocks_file_meta_source
  parameters:
    detached: 'False'
    file: infile
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: outfile
    type: complex
  states: {}
- name: infile
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}
- name: outfile
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}

connections:
- [blocks_file_meta_source_0, '0', blocks_file_sink_1, '0']

metadata:
  file_format: 1
