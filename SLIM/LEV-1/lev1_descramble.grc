options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: lev1_descramble
    output_language: python
    run_options: run
    title: LEV-1 descrambler
  states: {}

blocks:
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: bits_descrambled.u8
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: LLRs.f32
    repeat: 'False'
    type: float
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: satellites_descrambler308_0
  id: satellites_descrambler308
  parameters: {}
  states: {}

connections:
- [blocks_file_source_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_binary_slicer_fb_0, '0', satellites_descrambler308_0, '0']
- [satellites_descrambler308_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
