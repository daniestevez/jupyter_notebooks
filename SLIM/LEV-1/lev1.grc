options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: lev1
    output_language: python
    run_options: run
    title: LEV-1 demodulator
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '''''.join([str(i) for i in (syncword+1)//2])'
  states: {}
- name: baudrate
  id: variable
  parameters:
    value: '64'
  states: {}
- name: dec
  id: variable
  parameters:
    value: '50'
  states: {}
- name: dec2
  id: variable
  parameters:
    value: '20'
  states: {}
- name: dec_cw
  id: variable
  parameters:
    value: '50'
  states: {}
- name: pll_bw
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate / (baudrate * dec * dec2)
  states: {}
- name: subcarrier
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: syncword
  id: variable
  parameters:
    value: 2*np.unpackbits(np.frombuffer(bytes.fromhex(syncword_hex), dtype = 'uint8')).astype('int')-1
  states: {}
- name: syncword_hex
  id: variable
  parameters:
    value: '''FAF320'''
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: np.pi
    min_freq: '-np.pi'
    w: 2 * np.pi * pll_bw * dec / samp_rate
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: lev1_symbols.f32
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: lev1_cw.f32
    type: float
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: lev1_viterbi0.u8
    type: byte
  states: {}
- name: blocks_file_sink_0_1_0
  id: blocks_file_sink
  parameters:
    file: lev1_viterbi1.u8
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: slim_2024-01-19_15_39_58_437.200MHz_1.00Msps_ci16_le.chan0.sigmf-data
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate * 10
    type: complex
  states: {state: bypassed}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.01'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1] * int(sps)'
    type: ccf
  states: {}
- name: fir_filter_xxx_1_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: syncword[::-1]/syncword.size
    type: fff
  states: {}
- name: fir_filter_xxx_1_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: syncword[::-1]/syncword.size
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 210e3
    decim: dec
    samp_rate: samp_rate
    taps: firdes.low_pass(1, 1, 0.5/dec, 0.1/dec)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: subcarrier
    decim: dec2
    samp_rate: samp_rate/dec
    taps: firdes.low_pass(1, 1, 0.5/dec2, 0.1/dec2)
    type: fcf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '50'
    decim: dec_cw
    gain: '8000'
    interp: dec_cw
    samp_rate: samp_rate / dec
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 0,1,1,1
    name: '"Telemetry subcarrier constellation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate / dec
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,0,1,1
    name: '"PLL output spectrum"'
    nconnections: '2'
    type: float
    ymax: '-80'
    ymin: '-130'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,2
    name: '"Residual carrier amplitude"'
    size: '2000'
    srate: samp_rate / (dec * dec_cw)
    type: float
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: 2,0
    label1: Symbols
    label2: ASM correlation
    marker1: '0'
    name: Viterbi decoder 0
    nconnections: '2'
    size: 560 * 4
    srate: baudrate / 2
    style1: '0'
    tr_chan: '1'
    tr_delay: '1e-4'
    tr_level: '-0.8'
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: 2,1
    label1: Symbols
    label2: ASM correlation
    marker1: '0'
    name: Viterbi decoder 1
    nconnections: '2'
    size: 560 * 4
    srate: baudrate / 2
    style1: '0'
    tr_chan: '1'
    tr_delay: '1e-4'
    tr_level: '-0.8'
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}
- name: satellites_ccsds_viterbi_0
  id: satellites_ccsds_viterbi
  parameters: {}
  states: {}
- name: satellites_ccsds_viterbi_0_0
  id: satellites_ccsds_viterbi
  parameters: {}
  states: {}
- name: satellites_descrambler308_0
  id: satellites_descrambler308
  parameters: {}
  states: {}
- name: satellites_descrambler308_0_0
  id: satellites_descrambler308
  parameters: {}
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '0.8'
  states: {}

connections:
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_float_0, '0']
- [blocks_add_const_vxx_0, '0', fir_filter_xxx_1_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_add_const_vxx_0_0, '0', fir_filter_xxx_1_0_0, '0']
- [blocks_add_const_vxx_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_complex_to_float_0, '0', low_pass_filter_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', freq_xlating_fir_filter_xxx_1, '0']
- [blocks_complex_to_float_0, '1', qtgui_freq_sink_x_0, '1']
- [blocks_complex_to_real_0, '0', blocks_delay_0, '0']
- [blocks_complex_to_real_0, '0', blocks_file_sink_0, '0']
- [blocks_complex_to_real_0, '0', satellites_ccsds_viterbi_0, '0']
- [blocks_delay_0, '0', satellites_ccsds_viterbi_0_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0_1, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_file_sink_0_1_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_1, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [fir_filter_xxx_1, '0', satellites_rms_agc_0, '0']
- [fir_filter_xxx_1_0, '0', qtgui_time_sink_x_0_0, '1']
- [fir_filter_xxx_1_0_0, '0', qtgui_time_sink_x_0_0_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', analog_pll_carriertracking_cc_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', fir_filter_xxx_1, '0']
- [low_pass_filter_0, '0', blocks_file_sink_0_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [satellites_ccsds_viterbi_0, '0', satellites_descrambler308_0, '0']
- [satellites_ccsds_viterbi_0_0, '0', satellites_descrambler308_0_0, '0']
- [satellites_descrambler308_0, '0', blocks_char_to_float_0, '0']
- [satellites_descrambler308_0, '0', blocks_pack_k_bits_bb_0, '0']
- [satellites_descrambler308_0_0, '0', blocks_char_to_float_0_0, '0']
- [satellites_descrambler308_0_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [satellites_rms_agc_0, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
