options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: slim_doppler_correct
    output_language: python
    run_options: run
    title: SLIM Doppler correct
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '60'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '-21e3'
  states: {}
- name: pll_bw
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1152000'
  states: {}
- name: start_time
  id: variable
  parameters:
    value: '''2024-01-19T14:51:51Z'''
  states: {}
- name: start_time_unix
  id: variable
  parameters:
    value: datetime.datetime.fromisoformat(start_time).timestamp()
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: np.pi
    min_freq: '-np.pi'
    w: 2 * np.pi * pll_bw * decim / samp_rate
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: SLIM_2024-01-19_14-51-51_19200SPS_PLL.c64
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: '2024-01-19_14-51-51_1152000SPS_2212021000Hz.s16'
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, 1, 0.5/decim, 0.05/decim)
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import datetime
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: satellites_doppler_correction_0
  id: satellites_doppler_correction
  parameters:
    file: SLIM-doppler-Bochum-2024-01-19.txt
    samp_rate: samp_rate
    t0: start_time_unix
  states: {}
- name: satellites_doppler_correction_0_0
  id: satellites_doppler_correction
  parameters:
    file: SLIM-doppler-Usuda-2024-01-19.txt
    samp_rate: samp_rate
    t0: start_time_unix
  states: {}

connections:
- [analog_pll_carriertracking_cc_0, '0', blocks_file_sink_0_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', satellites_doppler_correction_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_pll_carriertracking_cc_0, '0']
- [satellites_doppler_correction_0, '0', satellites_doppler_correction_0_0, '0']
- [satellites_doppler_correction_0_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
