options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: queqiao
    output_language: python
    run_options: run
    title: Queqiao S-band telemetry decoder
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '2'
  states: {}
- name: decim2
  id: variable
  parameters:
    value: '10'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: 2048-32
  states: {}
- name: pll_bw
  id: variable
  parameters:
    value: '25'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 480e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/(decim*decim2*baudrate)
  states: {}
- name: syncword
  id: variable
  parameters:
    value: '''00011010110011111111110000011101'''
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: math.pi
    min_freq: '-math.pi'
    w: 2*math.pi*pll_bw/(samp_rate/decim)
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: queqiao_rs_frames.u8
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: input_file
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_not_xx_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_not_xx_0_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.01'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1/int(sps)]*int(sps)'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 20e3
    decim: '2'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 100e3, 10e3)
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '65536'
    decim: decim2
    samp_rate: samp_rate/decim
    taps: firdes.low_pass(1, samp_rate/decim, 10e3, 5e3)
    type: fcf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: input_file
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}
- name: satellites_ccsds_descrambler_0
  id: satellites_ccsds_descrambler
  parameters: {}
  states: {}
- name: satellites_ccsds_viterbi_0
  id: satellites_ccsds_viterbi
  parameters: {}
  states: {}
- name: satellites_ccsds_viterbi_0_0
  id: satellites_ccsds_viterbi
  parameters: {}
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1.0'
  states: {}
- name: satellites_rms_agc_1
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1.0'
  states: {}
- name: satellites_sync_to_pdu_0
  id: satellites_sync_to_pdu
  parameters:
    packlen: packet_len
    sync: syncword
    threshold: '4'
  states: {}
- name: satellites_sync_to_pdu_0_0
  id: satellites_sync_to_pdu
  parameters:
    packlen: packet_len
    sync: syncword
    threshold: '4'
  states: {}
- name: satellites_sync_to_pdu_0_1
  id: satellites_sync_to_pdu
  parameters:
    packlen: packet_len
    sync: syncword
    threshold: '4'
  states: {}
- name: satellites_sync_to_pdu_0_1_0
  id: satellites_sync_to_pdu
  parameters:
    packlen: packet_len
    sync: syncword
    threshold: '4'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: pll_in
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: subcarrier
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: viterbi1
  states: {}
- name: virtual_sink_1_1
  id: virtual_sink
  parameters:
    stream_id: viterbi0
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: symbol_sync
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: symbols
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: pll_in
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: symbols
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: viterbi1
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: viterbi0
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: subcarrier
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: symbol_sync
  states: {}

connections:
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_float_0, '0']
- [blocks_complex_to_float_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_float_0, '1', freq_xlating_fir_filter_xxx_1, '0']
- [blocks_complex_to_real_0, '0', virtual_sink_3, '0']
- [blocks_delay_1, '0', satellites_ccsds_viterbi_0_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_not_xx_0, '0', satellites_sync_to_pdu_0_1, '0']
- [blocks_not_xx_0_0, '0', satellites_sync_to_pdu_0_1_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_file_sink_1, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0, '0']
- [digital_symbol_sync_xx_0, '0', virtual_sink_2, '0']
- [fir_filter_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', satellites_rms_agc_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', virtual_sink_1, '0']
- [satellites_ccsds_descrambler_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [satellites_ccsds_viterbi_0, '0', virtual_sink_1_1, '0']
- [satellites_ccsds_viterbi_0_0, '0', virtual_sink_1_0, '0']
- [satellites_rms_agc_0, '0', virtual_sink_0, '0']
- [satellites_rms_agc_1, '0', fir_filter_xxx_0, '0']
- [satellites_sync_to_pdu_0, out, satellites_ccsds_descrambler_0, in]
- [satellites_sync_to_pdu_0_0, out, satellites_ccsds_descrambler_0, in]
- [satellites_sync_to_pdu_0_1, out, satellites_ccsds_descrambler_0, in]
- [satellites_sync_to_pdu_0_1_0, out, satellites_ccsds_descrambler_0, in]
- [virtual_source_0, '0', analog_pll_carriertracking_cc_0, '0']
- [virtual_source_0_0, '0', blocks_delay_1, '0']
- [virtual_source_0_0, '0', satellites_ccsds_viterbi_0, '0']
- [virtual_source_0_0_0, '0', blocks_not_xx_0_0, '0']
- [virtual_source_0_0_0, '0', satellites_sync_to_pdu_0_0, '0']
- [virtual_source_0_0_1, '0', blocks_not_xx_0, '0']
- [virtual_source_0_0_1, '0', satellites_sync_to_pdu_0, '0']
- [virtual_source_2, '0', satellites_rms_agc_1, '0']
- [virtual_source_3, '0', digital_costas_loop_cc_0, '0']

metadata:
  file_format: 1
