options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: roman
    output_language: python
    title: Roman telemetry decoder
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '19500'
  states: {}
- name: fir_delay
  id: variable
  parameters:
    value: '24.075'
  states: {}
- name: freq
  id: variable
  parameters:
    comment: This is for the first recording
    value: '-1200'
  states: {}
- name: freq
  id: variable
  parameters:
    comment: This is for the second recording
    value: '-2250'
  states: {state: disabled}
- name: pll_bw
  id: variable
  parameters:
    value: '50'
  states: {}
- name: residual_subcarrier
  id: variable
  parameters:
    value: '-10.3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '256_000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/baudrate
  states: {}
- name: syncword_threshold
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: np.pi
    min_freq: '-np.pi'
    w: pll_bw / samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: roman_frames.u8
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: Roman_2026-08-31T05_32_24_carrier.sigmf-meta
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: Roman_2026-08-31T05_32_24_subcarrier_high.sigmf-meta
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: Roman_2026-08-31T05_32_24_subcarrier_low.sigmf-meta
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_1
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_1_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_1_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-2*np.pi*residual_subcarrier/samp_rate'
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.001'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.01'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1/round(sps)]*round(sps)'
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
    xmax: '3'
    xmin: '-3'
    ymax: '3'
    ymin: '-3'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    nconnections: '4'
    type: float
  states: {}
- name: satellites_ccsds_concatenated_deframer_0
  id: satellites_ccsds_concatenated_deframer
  parameters:
    convolutional: '"CCSDS"'
    frame_size: 223 * 8
    precoding: None
    rs_basis: '"dual"'
    rs_interleaving: '8'
    scrambler: '"CCSDS"'
    threshold: syncword_threshold
  states: {}
- name: satellites_ccsds_concatenated_deframer_0_0
  id: satellites_ccsds_concatenated_deframer
  parameters:
    convolutional: '"CCSDS"'
    frame_size: 223 * 8
    precoding: None
    rs_basis: '"dual"'
    rs_interleaving: '8'
    scrambler: '"CCSDS"'
    threshold: syncword_threshold
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-3'
    reference: '1.2'
  states: {}

connections:
- [analog_pll_refout_cc_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [analog_pll_refout_cc_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [analog_pll_refout_cc_0, '0', blocks_multiply_conjugate_cc_0_0_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_conjugate_cc_0_1, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_conjugate_cc_0_1_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_conjugate_cc_0_1_0_0, '1']
- [blocks_complex_to_float_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_freq_sink_x_0, '1']
- [blocks_complex_to_float_1, '0', qtgui_freq_sink_x_0, '2']
- [blocks_complex_to_float_1, '1', qtgui_freq_sink_x_0, '3']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_real_0, '0', satellites_ccsds_concatenated_deframer_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_sub_xx_0, '1']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_interleaved_short_to_complex_0_0_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', blocks_multiply_conjugate_cc_0_1_0, '0']
- [blocks_interleaved_short_to_complex_0_0_0, '0', blocks_multiply_conjugate_cc_0_1_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', blocks_sub_xx_0, '0']
- [blocks_multiply_conjugate_cc_0_0_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_multiply_conjugate_cc_0_1, '0', analog_pll_refout_cc_0, '0']
- [blocks_multiply_conjugate_cc_0_1, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_multiply_conjugate_cc_0_1_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [blocks_multiply_conjugate_cc_0_1_0_0, '0', blocks_multiply_conjugate_cc_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', satellites_ccsds_concatenated_deframer_0_0, '0']
- [blocks_rotator_cc_0, '0', fir_filter_xxx_0, '0']
- [blocks_sub_xx_0, '0', blocks_complex_to_float_1, '0']
- [blocks_sub_xx_0, '0', blocks_rotator_cc_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_conjugate_cc_0_1, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [fir_filter_xxx_0, '0', satellites_rms_agc_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [satellites_ccsds_concatenated_deframer_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [satellites_ccsds_concatenated_deframer_0, out, satellites_hexdump_sink_0, in]
- [satellites_ccsds_concatenated_deframer_0_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [satellites_ccsds_concatenated_deframer_0_0, out, satellites_hexdump_sink_0, in]
- [satellites_rms_agc_0, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
