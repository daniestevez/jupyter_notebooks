options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: wcube_doppler
    output_language: python
    title: W-CUBE Doppler correction
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '200'
  states: {}
- name: decim2
  id: variable
  parameters:
    value: '20'
  states: {}
- name: delta_t
  id: variable
  parameters:
    value: '3.7'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '4500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: start_time
  id: variable
  parameters:
    value: 1686924577 + delta_t
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: doppler_corrected.c64
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/contracting/w-cube/wc_20230616_dump_1686924577.bin/wc_20230616_dump_1686924577.bin
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    comment: Swap is enabled to handle spectral inversion
    scale_factor: 2**15
    swap: 'True'
    vector_input: 'False'
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-2 * np.pi * freq_offset * decim / samp_rate'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 0.5 * samp_rate / decim
    decim: decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate / decim - samp_rate / (decim * decim2)
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 0.5 * samp_rate / (decim * decim2)
    decim: decim2
    gain: '1'
    samp_rate: samp_rate / decim
    type: fir_filter_ccf
    width: 0.05 * samp_rate / (decim * decim2)
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / (decim * decim2)
    fc: '0'
    fftsize: '512'
    type: complex
  states: {}
- name: satellites_doppler_correction_0
  id: satellites_doppler_correction
  parameters:
    file: doppler_1686924577.txt
    samp_rate: samp_rate
    t0: start_time
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', satellites_doppler_correction_0, '0']
- [blocks_rotator_cc_0, '0', low_pass_filter_1, '0']
- [low_pass_filter_0, '0', blocks_rotator_cc_0, '0']
- [low_pass_filter_1, '0', blocks_file_sink_0, '0']
- [low_pass_filter_1, '0', qtgui_freq_sink_x_0, '0']
- [satellites_doppler_correction_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
