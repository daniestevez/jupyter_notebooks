options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: hakuto
    output_language: python
    title: HAKUTO decoder
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '''''.join([str(i) for i in (syncword+1)//2])'
  states: {}
- name: baudrate
  id: variable
  parameters:
    value: 16e3
  states: {}
- name: decim
  id: variable
  parameters:
    value: '19'
  states: {}
- name: pll_bw
  id: variable
  parameters:
    value: '25'
  states: {}
- name: pll_limit
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1250000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate / (baudrate * decim)
  states: {}
- name: subcarrier
  id: variable
  parameters:
    value: 128.515e3
  states: {}
- name: syncword
  id: variable
  parameters:
    value: 2*np.unpackbits(np.frombuffer(bytes.fromhex(syncword_hex), dtype = 'uint8')).astype('int')-1
  states: {}
- name: syncword_hex
  id: variable
  parameters:
    value: '''034776C7272895B0'''
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: 2 * np.pi * pll_limit / samp_rate
    min_freq: '-2 * np.pi * pll_limit / samp_rate'
    w: 2 * np.pi * pll_bw / samp_rate
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: hakuto_frames.u8
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: tc_subcarrier.c64
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/Downloads/SDRSharp_20221211_224843Z_8492513720Hz_IQ.wav
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/Downloads/SDRSharp_20221211_232308Z_8492512825Hz_IQ.wav
    repeat: 'False'
    type: short
  states: {state: disabled}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.001'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.005'
    max_dev: '0.01'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: dslwp_ccsds_pseudo_randomizer_0
  id: dslwp_ccsds_pseudo_randomizer
  parameters:
    data_format: '3'
  states: {}
- name: dslwp_ccsds_turbo_decode_0
  id: dslwp_ccsds_turbo_decode
  parameters:
    base: '223'
    code_type: '2'
    iterations: '50'
    octets: '5'
    sigma: '1'
    update_sigma: '1'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1.7 / int(sps)] * int(sps)'
    type: ccc
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: syncword[::-1]/syncword.size
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: subcarrier
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, 1, 0.5/decim, 0.1/decim)
    type: fcf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 16e3
    decim: '200'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, 1, 0.5/200, 0.1/200)
    type: fcf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 0.5/4
    decim: '4'
    gain: '1'
    samp_rate: '1'
    type: fir_filter_ccf
    width: 0.1/4
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 0,1,1,1
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,0,1,1
    nconnections: '2'
    type: float
    ymax: '-70'
    ymin: '-105'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,2
    marker1: '0'
    nconnections: '2'
    size: '100000'
    srate: baudrate
    style1: '0'
    tr_chan: '1'
    tr_delay: '1e-4'
    tr_level: '-0.8'
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}
- name: satellites_crc_check_0
  id: satellites_crc_check
  parameters:
    discard_crc: 'True'
    final_xor: '0x0'
    initial_value: '0xFFFF'
    input_reflected: 'False'
    num_bits: '16'
    poly: '0x1021'
    result_reflected: 'False'
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {state: disabled}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-4'
    reference: '1.0'
  states: {}
- name: satellites_sync_to_pdu_soft_0
  id: satellites_sync_to_pdu_soft
  parameters:
    packlen: '17848'
    sync: access_code
    threshold: '12'
  states: {}
- name: satellites_sync_to_pdu_soft_0_0
  id: satellites_sync_to_pdu_soft
  parameters:
    packlen: '17848'
    sync: access_code
    threshold: '12'
  states: {}

connections:
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_float_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_complex_to_float_0, '1', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_freq_sink_x_0, '1']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_real_0, '0', fir_filter_xxx_1, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0, '0', satellites_sync_to_pdu_soft_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', satellites_sync_to_pdu_soft_0_0, '0']
- [blocks_throttle_0, '0', analog_pll_carriertracking_cc_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [dslwp_ccsds_pseudo_randomizer_0, out, dslwp_ccsds_turbo_decode_0, in]
- [dslwp_ccsds_turbo_decode_0, out, satellites_crc_check_0, in]
- [fir_filter_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [fir_filter_xxx_1, '0', qtgui_time_sink_x_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', satellites_rms_agc_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_file_sink_1, '0']
- [low_pass_filter_0, '0', blocks_throttle_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [satellites_crc_check_0, ok, pdu_pdu_to_tagged_stream_0, pdus]
- [satellites_crc_check_0, ok, satellites_hexdump_sink_0, in]
- [satellites_rms_agc_0, '0', fir_filter_xxx_0, '0']
- [satellites_sync_to_pdu_soft_0, out, dslwp_ccsds_pseudo_randomizer_0, in]
- [satellites_sync_to_pdu_soft_0_0, out, dslwp_ccsds_pseudo_randomizer_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.4.0
