options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: bw3
    output_language: python
    title: BlueWalker 3 decoder
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: 128e3 if samp_rate == 1000000 else 512e3
  states: {}
- name: decim
  id: variable
  parameters:
    value: 2 if samp_rate == 1000000 else 1
  states: {}
- name: deviation
  id: variable
  parameters:
    value: baudrate/4
  states: {}
- name: file_id
  id: variable
  parameters:
    value: '''_20220925_051912'''
  states: {}
- name: file_id
  id: variable
  parameters:
    value: '''_20221005_192459'''
  states: {state: disabled}
- name: frame_size_bytes
  id: variable
  parameters:
    value: 355 if baudrate == 128e3 else 1219
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {state: disabled}
- name: sps
  id: variable
  parameters:
    value: samp_rate/(baudrate*decim)
  states: {}
- name: sync_threshold
  id: variable
  parameters:
    value: '0'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*np.pi*deviation*decim)
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: f'bw3_frames{file_id}.u8'
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: f'bw3_symbols{file_id}.f32'
    type: float
  states: {}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: f'viterbi_out_1{file_id}.u8'
    type: byte
  states: {}
- name: blocks_file_sink_2_0
  id: blocks_file_sink
  parameters:
    file: f'viterbi_out_0{file_id}.u8'
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/Downloads/firefox/gqrx_20220925_051912_2245000000_1000000_fc_crop.raw
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/Downloads/firefox/gqrx_20221005_192459_2245000000_2000000_fc.raw
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.03'
    max_dev: '0.01'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1/round(sps)]*round(sps)'
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 22e3
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 100e3, 25e3)
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 300e3, 50e3)
    type: ccf
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decim
    fc: '0'
    fftsize: '1024'
    type: complex
    ymax: '-30'
    ymin: '-80'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    size: int(baudrate)//16
    srate: samp_rate
    style1: '0'
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}
- name: satellites_ccsds_descrambler_0
  id: satellites_ccsds_descrambler
  parameters: {}
  states: {}
- name: satellites_ccsds_viterbi_0
  id: satellites_ccsds_viterbi
  parameters: {}
  states: {}
- name: satellites_ccsds_viterbi_0_0
  id: satellites_ccsds_viterbi
  parameters: {}
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {state: disabled}
- name: satellites_sync_to_pdu_0
  id: satellites_sync_to_pdu
  parameters:
    packlen: frame_size_bytes * 8
    sync: '"00011010110011111111110000011101"'
    threshold: sync_threshold
  states: {}
- name: satellites_sync_to_pdu_0_0
  id: satellites_sync_to_pdu
  parameters:
    packlen: frame_size_bytes * 8
    sync: '"00011010110011111111110000011101"'
    threshold: sync_threshold
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', fir_filter_xxx_0, '0']
- [blocks_delay_0, '0', satellites_ccsds_viterbi_0_0, '0']
- [blocks_file_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_file_source_0_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_delay_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_file_sink_1, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', satellites_ccsds_viterbi_0, '0']
- [fir_filter_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [satellites_ccsds_descrambler_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [satellites_ccsds_descrambler_0, out, satellites_hexdump_sink_0, in]
- [satellites_ccsds_viterbi_0, '0', blocks_file_sink_2_0, '0']
- [satellites_ccsds_viterbi_0, '0', satellites_sync_to_pdu_0, '0']
- [satellites_ccsds_viterbi_0_0, '0', blocks_file_sink_2, '0']
- [satellites_ccsds_viterbi_0_0, '0', satellites_sync_to_pdu_0_0, '0']
- [satellites_sync_to_pdu_0, out, satellites_ccsds_descrambler_0, in]
- [satellites_sync_to_pdu_0_0, out, satellites_ccsds_descrambler_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.4.0
