options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: jwst_seq_ranging
    output_language: python
    run_options: run
    title: JWST sequential ranging
  states: {}

blocks:
- name: clock_component
  id: variable
  parameters:
    value: '4'
  states: {}
- name: downlink_freq
  id: variable
  parameters:
    value: 2270.5e6
  states: {}
- name: f0
  id: variable
  parameters:
    value: downlink_freq*221/240*2**-7
  states: {}
- name: f_last
  id: variable
  parameters:
    value: f0*2**-last_component
  states: {}
- name: last_component
  id: variable
  parameters:
    value: '17'
  states: {}
- name: pll_bw
  id: variable
  parameters:
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 3.84e6
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: '3.14'
    min_freq: '-3.14'
    w: 2*3.14*pll_bw/samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 14e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: f_last
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_exponentiate_const_cci_0
  id: blocks_exponentiate_const_cci
  parameters:
    exponent: '2'
  states: {}
- name: blocks_exponentiate_const_cci_0_0
  id: blocks_exponentiate_const_cci
  parameters:
    exponent: '2'
  states: {}
- name: blocks_exponentiate_const_cci_0_1
  id: blocks_exponentiate_const_cci
  parameters:
    exponent: '2'
  states: {}
- name: blocks_exponentiate_const_cci_0_10
  id: blocks_exponentiate_const_cci
  parameters:
    exponent: '2'
  states: {}
- name: blocks_exponentiate_const_cci_0_11
  id: blocks_exponentiate_const_cci
  parameters:
    exponent: '2'
  states: {}
- name: blocks_exponentiate_const_cci_0_2
  id: blocks_exponentiate_const_cci
  parameters:
    exponent: '2'
  states: {}
- name: blocks_exponentiate_const_cci_0_3
  id: blocks_exponentiate_const_cci
  parameters:
    exponent: '2'
  states: {}
- name: blocks_exponentiate_const_cci_0_4
  id: blocks_exponentiate_const_cci
  parameters:
    exponent: '2'
  states: {}
- name: blocks_exponentiate_const_cci_0_5
  id: blocks_exponentiate_const_cci
  parameters:
    exponent: '2'
  states: {}
- name: blocks_exponentiate_const_cci_0_6
  id: blocks_exponentiate_const_cci
  parameters:
    exponent: '2'
  states: {}
- name: blocks_exponentiate_const_cci_0_7
  id: blocks_exponentiate_const_cci
  parameters:
    exponent: '2'
  states: {}
- name: blocks_exponentiate_const_cci_0_8
  id: blocks_exponentiate_const_cci
  parameters:
    exponent: '2'
  states: {}
- name: blocks_exponentiate_const_cci_0_9
  id: blocks_exponentiate_const_cci
  parameters:
    exponent: '2'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: seq4.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: seq5u.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: seq5l.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: seq6l.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_1
  id: blocks_file_sink
  parameters:
    file: seq7l.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_2
  id: blocks_file_sink
  parameters:
    file: seq8l.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_3
  id: blocks_file_sink
  parameters:
    file: seq9l.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_4
  id: blocks_file_sink
  parameters:
    file: seq10l.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_5
  id: blocks_file_sink
  parameters:
    file: seq11l.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_6
  id: blocks_file_sink
  parameters:
    file: seq12l.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_6_0
  id: blocks_file_sink
  parameters:
    file: seq15l.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_7
  id: blocks_file_sink
  parameters:
    file: seq13l.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_7_0
  id: blocks_file_sink
  parameters:
    file: seq16l.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_8
  id: blocks_file_sink
  parameters:
    file: seq14l.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_8_0
  id: blocks_file_sink
  parameters:
    file: seq17l.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: seq6u.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0_2
  id: blocks_file_sink
  parameters:
    file: seq7u.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0_3
  id: blocks_file_sink
  parameters:
    file: seq8u.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0_4
  id: blocks_file_sink
  parameters:
    file: seq9u.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0_5
  id: blocks_file_sink
  parameters:
    file: seq10u.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0_6
  id: blocks_file_sink
  parameters:
    file: seq11u.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0_7
  id: blocks_file_sink
  parameters:
    file: seq12u.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0_7_0
  id: blocks_file_sink
  parameters:
    file: seq15u.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0_8
  id: blocks_file_sink
  parameters:
    file: seq13u.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0_8_0
  id: blocks_file_sink
  parameters:
    file: seq16u.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0_9
  id: blocks_file_sink
  parameters:
    file: seq14u.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0_9_0
  id: blocks_file_sink
  parameters:
    file: seq17u.c64
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: JWST_2021-12-26T07:13:56.865585_0x
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: JWST_2021-12-26T07:13:56.865585_0y
    repeat: 'False'
    type: short
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '10'
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '10'
    vector_input: 'False'
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_1
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_1_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_1_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_1_0_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_1_0_0_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_1_0_0_0_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_1_0_0_0_0_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_1_0_0_0_0_0_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_1_0_0_0_0_0_0_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_1_0_0_0_0_0_0_0_1
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_1_0_0_0_0_0_0_0_2
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_1_0_0_0_0_0_0_0_3
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_1_0_0_0_0_0_0_0_3_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0_0_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0_0_0_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0_0_0_0_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0_0_0_0_0_0_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0_0_0_0_0_0_0_2
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0_0_0_0_0_0_0_3
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0_0_0_0_0_0_0_3_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Auto-polarization
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Auto-polarization"""

          def __init__(self, fft_size=1024, fft_avg=1,
                           iir_weight = 1e-2): # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Auto-polarization',   # will show up in GRC
                  in_sig=[np.complex64]*2,
                  out_sig=[np.complex64]*2
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.fft_size = fft_size
              self.fft_avg = fft_avg
              self.set_output_multiple(fft_size * fft_avg)
              self.iir_weight = iir_weight
              self.noise_ampl = np.ones(2)
              self.sig_ampl = np.ones(2)
              self.phase = 0

          def work(self, input_items, output_items):
              x = np.array([inp.reshape((-1, self.fft_avg, self.fft_size))
                                for inp in input_items])
              # axes for x are:
              # (channel: 2, block, fft_num: fft_avg, fft_bin: fft_size)

              fx = np.fft.fft(x)
              fx_sq_avg = np.average(np.abs(fx)**2, axis = 2)
              noise_ampl = np.sqrt(np.median(fx_sq_avg, axis = 2))

              fx_sq_avg_ch_max = np.max(fx_sq_avg/noise_ampl[...,np.newaxis]**2, axis = 0)
              peak_idx = np.argmax(fx_sq_avg_ch_max, axis = 1)

              f_cross = np.average(fx[0] * np.conjugate(fx[1]), axis = 1)
              phase = np.angle(f_cross[np.arange(f_cross.shape[0]),
                                           peak_idx])
              sig_ampl = fx_sq_avg[:,np.arange(fx_sq_avg.shape[1]),peak_idx] #- noise_ampl
              sig_ampl = np.sqrt(np.clip(sig_ampl, 0, np.inf))

              # update IIR filters
              for j in range(x.shape[1]):
                  noise_ampl[:,j] = (1-self.iir_weight)*self.noise_ampl \
                    + self.iir_weight*noise_ampl[:,j]
                  self.noise_ampl = noise_ampl[:,j]
                  sig_ampl[:,j] = (1-self.iir_weight)*self.sig_ampl \
                    + self.iir_weight*sig_ampl[:,j]
                  self.sig_ampl = sig_ampl[:,j]
                  phase_diff = phase[j] - self.phase
                  phase_diff = (phase_diff + np.pi) % (2*np.pi) - np.pi
                  phase[j] = self.phase + self.iir_weight*phase_diff
                  self.phase = (phase[j] + np.pi) % (2*np.pi) - np.pi

              tau = np.log10(sig_ampl[0]/noise_ampl[0]+1e-6) \
                - np.log10(sig_ampl[1]/noise_ampl[1]+1e-6)
              tau = 20*tau/6*0.5 + 0.5
              tau = np.clip(tau, 0, 1)
              # note tau = 1 if sig[0] is 6dB stronger than sig[1] and
              # tau = 0 if sig[0] is 6dB weaker than sig[1]
              a_phase = (tau - 1) * phase
              b_phase = tau * phase
              # note -a_phase + b_phase = phase
              
              alpha = (np.exp(1j*a_phase) * sig_ampl[0] / noise_ampl[0])[:,np.newaxis]
              beta = (np.exp(1j*b_phase) * sig_ampl[1] / noise_ampl[1])[:,np.newaxis]

              y = x.reshape((x.shape[0], x.shape[1], self.fft_avg * self.fft_size))
              y = y / noise_ampl[...,np.newaxis] * np.sqrt(self.fft_size)
              output_items[0][:] = (alpha * y[0] + beta * y[1]).ravel()
              output_items[1][:] = (np.conjugate(beta) * y[0] - np.conjugate(alpha) * y[1]).ravel()
              return len(output_items[0])
    fft_avg: int(0.1*samp_rate/2048)
    fft_size: '2048'
    iir_weight: '0.1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '384'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3-200
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '384'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3-200
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '384'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3-200
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '384'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3-200
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '384'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3-200
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '384'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3-200
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_3
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '384'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3-200
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_4
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '384'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3-200
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_5
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '384'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3-200
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_6
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '384'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3-200
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_6_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '384'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3-200
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_7
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '384'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3-200
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_7_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '384'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3-200
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_8
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '384'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3-200
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_8_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '384'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3-200
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '384'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3-200
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '384'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3-200
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_3
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '384'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3-200
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_4
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '384'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3-200
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_5
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '384'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3-200
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_6
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '384'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3-200
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_7
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '384'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3-200
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_7_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '384'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3-200
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_8
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '384'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3-200
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_8_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '384'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3-200
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_9
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '384'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3-200
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_9_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '384'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3-200
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '45'
    decim: '100'
    gain: '1'
    samp_rate: '10000'
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '45'
    decim: '100'
    gain: '1'
    samp_rate: '10000'
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '45'
    decim: '100'
    gain: '1'
    samp_rate: '10000'
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '45'
    decim: '100'
    gain: '1'
    samp_rate: '10000'
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '45'
    decim: '100'
    gain: '1'
    samp_rate: '10000'
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_0_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '45'
    decim: '100'
    gain: '1'
    samp_rate: '10000'
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_0_3
  id: low_pass_filter
  parameters:
    cutoff_freq: '45'
    decim: '100'
    gain: '1'
    samp_rate: '10000'
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_0_4
  id: low_pass_filter
  parameters:
    cutoff_freq: '45'
    decim: '100'
    gain: '1'
    samp_rate: '10000'
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_0_5
  id: low_pass_filter
  parameters:
    cutoff_freq: '45'
    decim: '100'
    gain: '1'
    samp_rate: '10000'
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_0_6
  id: low_pass_filter
  parameters:
    cutoff_freq: '45'
    decim: '100'
    gain: '1'
    samp_rate: '10000'
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_0_6_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '45'
    decim: '100'
    gain: '1'
    samp_rate: '10000'
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_0_7
  id: low_pass_filter
  parameters:
    cutoff_freq: '45'
    decim: '100'
    gain: '1'
    samp_rate: '10000'
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_0_7_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '45'
    decim: '100'
    gain: '1'
    samp_rate: '10000'
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_0_8
  id: low_pass_filter
  parameters:
    cutoff_freq: '45'
    decim: '100'
    gain: '1'
    samp_rate: '10000'
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_0_8_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '45'
    decim: '100'
    gain: '1'
    samp_rate: '10000'
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '45'
    decim: '100'
    gain: '1'
    samp_rate: '10000'
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '45'
    decim: '100'
    gain: '1'
    samp_rate: '10000'
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_3
  id: low_pass_filter
  parameters:
    cutoff_freq: '45'
    decim: '100'
    gain: '1'
    samp_rate: '10000'
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_4
  id: low_pass_filter
  parameters:
    cutoff_freq: '45'
    decim: '100'
    gain: '1'
    samp_rate: '10000'
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_5
  id: low_pass_filter
  parameters:
    cutoff_freq: '45'
    decim: '100'
    gain: '1'
    samp_rate: '10000'
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_6
  id: low_pass_filter
  parameters:
    cutoff_freq: '45'
    decim: '100'
    gain: '1'
    samp_rate: '10000'
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_7
  id: low_pass_filter
  parameters:
    cutoff_freq: '45'
    decim: '100'
    gain: '1'
    samp_rate: '10000'
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_7_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '45'
    decim: '100'
    gain: '1'
    samp_rate: '10000'
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_8
  id: low_pass_filter
  parameters:
    cutoff_freq: '45'
    decim: '100'
    gain: '1'
    samp_rate: '10000'
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_8_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '45'
    decim: '100'
    gain: '1'
    samp_rate: '10000'
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_9
  id: low_pass_filter
  parameters:
    cutoff_freq: '45'
    decim: '100'
    gain: '1'
    samp_rate: '10000'
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_9_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '45'
    decim: '100'
    gain: '1'
    samp_rate: '10000'
    type: fir_filter_ccf
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate/decim
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,0,1,1
    label1: X polarization
    label2: Y polarization
    label3: Combination
    name: Polarization combination
    nconnections: '3'
    type: complex
    ymax: '0'
    ymin: '-35'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate/decim
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,1,1,1
    label1: In-phase
    label2: Quadrature
    name: PLL output
    nconnections: '2'
    type: float
    ymax: '0'
    ymin: '-35'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: phase_mod
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: phase_mod
  states: {}

connections:
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_float_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_1, '0', blocks_exponentiate_const_cci_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_conjugate_cc_1_0_0_0_0_0_0_0_3_0, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1_0_0_0_0_0_0_0_3_0, '1']
- [blocks_complex_to_float_0, '0', blocks_null_sink_1, '0']
- [blocks_complex_to_float_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_freq_sink_x_0_0, '1']
- [blocks_complex_to_float_0, '1', virtual_sink_0, '0']
- [blocks_exponentiate_const_cci_0, '0', blocks_exponentiate_const_cci_0_0, '0']
- [blocks_exponentiate_const_cci_0, '0', blocks_multiply_conjugate_cc_1_0_0_0_0_0_0_0_3, '1']
- [blocks_exponentiate_const_cci_0, '0', blocks_multiply_xx_1_0_0_0_0_0_0_0_3, '1']
- [blocks_exponentiate_const_cci_0_0, '0', blocks_exponentiate_const_cci_0_1, '0']
- [blocks_exponentiate_const_cci_0_0, '0', blocks_multiply_conjugate_cc_1_0_0_0_0_0_0_0_2, '1']
- [blocks_exponentiate_const_cci_0_0, '0', blocks_multiply_xx_1_0_0_0_0_0_0_0_2, '1']
- [blocks_exponentiate_const_cci_0_1, '0', blocks_exponentiate_const_cci_0_2, '0']
- [blocks_exponentiate_const_cci_0_1, '0', blocks_multiply_conjugate_cc_1_0_0_0_0_0_0_0_1, '1']
- [blocks_exponentiate_const_cci_0_1, '0', blocks_multiply_xx_1_0_0_0_0_0_0_0_1, '1']
- [blocks_exponentiate_const_cci_0_10, '0', blocks_exponentiate_const_cci_0_11, '0']
- [blocks_exponentiate_const_cci_0_10, '0', blocks_multiply_conjugate_cc_1, '1']
- [blocks_exponentiate_const_cci_0_10, '0', blocks_multiply_xx_1, '1']
- [blocks_exponentiate_const_cci_0_11, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_exponentiate_const_cci_0_2, '0', blocks_exponentiate_const_cci_0_3, '0']
- [blocks_exponentiate_const_cci_0_2, '0', blocks_multiply_conjugate_cc_1_0_0_0_0_0_0_0_0, '1']
- [blocks_exponentiate_const_cci_0_2, '0', blocks_multiply_xx_1_0_0_0_0_0_0_0_0, '1']
- [blocks_exponentiate_const_cci_0_3, '0', blocks_exponentiate_const_cci_0_4, '0']
- [blocks_exponentiate_const_cci_0_3, '0', blocks_multiply_conjugate_cc_1_0_0_0_0_0_0_0, '1']
- [blocks_exponentiate_const_cci_0_3, '0', blocks_multiply_xx_1_0_0_0_0_0_0_0, '1']
- [blocks_exponentiate_const_cci_0_4, '0', blocks_exponentiate_const_cci_0_5, '0']
- [blocks_exponentiate_const_cci_0_4, '0', blocks_multiply_conjugate_cc_1_0_0_0_0_0_0, '1']
- [blocks_exponentiate_const_cci_0_4, '0', blocks_multiply_xx_1_0_0_0_0_0_0, '1']
- [blocks_exponentiate_const_cci_0_5, '0', blocks_exponentiate_const_cci_0_6, '0']
- [blocks_exponentiate_const_cci_0_5, '0', blocks_multiply_conjugate_cc_1_0_0_0_0_0, '1']
- [blocks_exponentiate_const_cci_0_5, '0', blocks_multiply_xx_1_0_0_0_0_0, '1']
- [blocks_exponentiate_const_cci_0_6, '0', blocks_exponentiate_const_cci_0_7, '0']
- [blocks_exponentiate_const_cci_0_6, '0', blocks_multiply_conjugate_cc_1_0_0_0_0, '1']
- [blocks_exponentiate_const_cci_0_6, '0', blocks_multiply_xx_1_0_0_0_0, '1']
- [blocks_exponentiate_const_cci_0_7, '0', blocks_exponentiate_const_cci_0_8, '0']
- [blocks_exponentiate_const_cci_0_7, '0', blocks_multiply_conjugate_cc_1_0_0_0, '1']
- [blocks_exponentiate_const_cci_0_7, '0', blocks_multiply_xx_1_0_0_0, '1']
- [blocks_exponentiate_const_cci_0_8, '0', blocks_exponentiate_const_cci_0_9, '0']
- [blocks_exponentiate_const_cci_0_8, '0', blocks_multiply_conjugate_cc_1_0_0, '1']
- [blocks_exponentiate_const_cci_0_8, '0', blocks_multiply_xx_1_0_0, '1']
- [blocks_exponentiate_const_cci_0_9, '0', blocks_exponentiate_const_cci_0_10, '0']
- [blocks_exponentiate_const_cci_0_9, '0', blocks_multiply_conjugate_cc_1_0, '1']
- [blocks_exponentiate_const_cci_0_9, '0', blocks_multiply_xx_1_0, '1']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_conjugate_cc_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_conjugate_cc_1_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_conjugate_cc_1_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_conjugate_cc_1_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_conjugate_cc_1_0_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_conjugate_cc_1_0_0_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_conjugate_cc_1_0_0_0_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_conjugate_cc_1_0_0_0_0_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_conjugate_cc_1_0_0_0_0_0_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_conjugate_cc_1_0_0_0_0_0_0_0_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_conjugate_cc_1_0_0_0_0_0_0_0_2, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_conjugate_cc_1_0_0_0_0_0_0_0_3, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_conjugate_cc_1_0_0_0_0_0_0_0_3_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_xx_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_xx_1_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_xx_1_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_xx_1_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_xx_1_0_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_xx_1_0_0_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_xx_1_0_0_0_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_xx_1_0_0_0_0_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_xx_1_0_0_0_0_0_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_xx_1_0_0_0_0_0_0_0_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_xx_1_0_0_0_0_0_0_0_2, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_xx_1_0_0_0_0_0_0_0_3, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_xx_1_0_0_0_0_0_0_0_3_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_conjugate_cc_1, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_conjugate_cc_1_0, '0', low_pass_filter_0_0_1, '0']
- [blocks_multiply_conjugate_cc_1_0_0, '0', low_pass_filter_0_0_2, '0']
- [blocks_multiply_conjugate_cc_1_0_0_0, '0', low_pass_filter_0_0_3, '0']
- [blocks_multiply_conjugate_cc_1_0_0_0_0, '0', low_pass_filter_0_0_4, '0']
- [blocks_multiply_conjugate_cc_1_0_0_0_0_0, '0', low_pass_filter_0_0_5, '0']
- [blocks_multiply_conjugate_cc_1_0_0_0_0_0_0, '0', low_pass_filter_0_0_6, '0']
- [blocks_multiply_conjugate_cc_1_0_0_0_0_0_0_0, '0', low_pass_filter_0_0_7, '0']
- [blocks_multiply_conjugate_cc_1_0_0_0_0_0_0_0_0, '0', low_pass_filter_0_0_8, '0']
- [blocks_multiply_conjugate_cc_1_0_0_0_0_0_0_0_1, '0', low_pass_filter_0_0_9, '0']
- [blocks_multiply_conjugate_cc_1_0_0_0_0_0_0_0_2, '0', low_pass_filter_0_0_7_0, '0']
- [blocks_multiply_conjugate_cc_1_0_0_0_0_0_0_0_3, '0', low_pass_filter_0_0_8_0, '0']
- [blocks_multiply_conjugate_cc_1_0_0_0_0_0_0_0_3_0, '0', low_pass_filter_0_0_9_0, '0']
- [blocks_multiply_xx_0, '0', epy_block_0, '0']
- [blocks_multiply_xx_0_0, '0', epy_block_0, '1']
- [blocks_multiply_xx_1, '0', low_pass_filter_0_0_0, '0']
- [blocks_multiply_xx_1_0, '0', low_pass_filter_0_0_0_0, '0']
- [blocks_multiply_xx_1_0_0, '0', low_pass_filter_0_0_0_1, '0']
- [blocks_multiply_xx_1_0_0_0, '0', low_pass_filter_0_0_0_2, '0']
- [blocks_multiply_xx_1_0_0_0_0, '0', low_pass_filter_0_0_0_3, '0']
- [blocks_multiply_xx_1_0_0_0_0_0, '0', low_pass_filter_0_0_0_4, '0']
- [blocks_multiply_xx_1_0_0_0_0_0_0, '0', low_pass_filter_0_0_0_5, '0']
- [blocks_multiply_xx_1_0_0_0_0_0_0_0, '0', low_pass_filter_0_0_0_6, '0']
- [blocks_multiply_xx_1_0_0_0_0_0_0_0_0, '0', low_pass_filter_0_0_0_7, '0']
- [blocks_multiply_xx_1_0_0_0_0_0_0_0_1, '0', low_pass_filter_0_0_0_8, '0']
- [blocks_multiply_xx_1_0_0_0_0_0_0_0_2, '0', low_pass_filter_0_0_0_6_0, '0']
- [blocks_multiply_xx_1_0_0_0_0_0_0_0_3, '0', low_pass_filter_0_0_0_7_0, '0']
- [blocks_multiply_xx_1_0_0_0_0_0_0_0_3_0, '0', low_pass_filter_0_0_0_8_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [epy_block_0, '0', analog_pll_carriertracking_cc_0, '0']
- [epy_block_0, '0', qtgui_freq_sink_x_0, '2']
- [epy_block_0, '1', blocks_null_sink_0, '0']
- [low_pass_filter_0, '0', low_pass_filter_1, '0']
- [low_pass_filter_0_0, '0', low_pass_filter_1_0, '0']
- [low_pass_filter_0_0_0, '0', low_pass_filter_1_0_0, '0']
- [low_pass_filter_0_0_0_0, '0', low_pass_filter_1_0_0_0, '0']
- [low_pass_filter_0_0_0_1, '0', low_pass_filter_1_0_0_1, '0']
- [low_pass_filter_0_0_0_2, '0', low_pass_filter_1_0_0_2, '0']
- [low_pass_filter_0_0_0_3, '0', low_pass_filter_1_0_0_3, '0']
- [low_pass_filter_0_0_0_4, '0', low_pass_filter_1_0_0_4, '0']
- [low_pass_filter_0_0_0_5, '0', low_pass_filter_1_0_0_5, '0']
- [low_pass_filter_0_0_0_6, '0', low_pass_filter_1_0_0_6, '0']
- [low_pass_filter_0_0_0_6_0, '0', low_pass_filter_1_0_0_6_0, '0']
- [low_pass_filter_0_0_0_7, '0', low_pass_filter_1_0_0_7, '0']
- [low_pass_filter_0_0_0_7_0, '0', low_pass_filter_1_0_0_7_0, '0']
- [low_pass_filter_0_0_0_8, '0', low_pass_filter_1_0_0_8, '0']
- [low_pass_filter_0_0_0_8_0, '0', low_pass_filter_1_0_0_8_0, '0']
- [low_pass_filter_0_0_1, '0', low_pass_filter_1_0_1, '0']
- [low_pass_filter_0_0_2, '0', low_pass_filter_1_0_2, '0']
- [low_pass_filter_0_0_3, '0', low_pass_filter_1_0_3, '0']
- [low_pass_filter_0_0_4, '0', low_pass_filter_1_0_4, '0']
- [low_pass_filter_0_0_5, '0', low_pass_filter_1_0_5, '0']
- [low_pass_filter_0_0_6, '0', low_pass_filter_1_0_6, '0']
- [low_pass_filter_0_0_7, '0', low_pass_filter_1_0_7, '0']
- [low_pass_filter_0_0_7_0, '0', low_pass_filter_1_0_7_0, '0']
- [low_pass_filter_0_0_8, '0', low_pass_filter_1_0_8, '0']
- [low_pass_filter_0_0_8_0, '0', low_pass_filter_1_0_8_0, '0']
- [low_pass_filter_0_0_9, '0', low_pass_filter_1_0_9, '0']
- [low_pass_filter_0_0_9_0, '0', low_pass_filter_1_0_9_0, '0']
- [low_pass_filter_1, '0', blocks_file_sink_0, '0']
- [low_pass_filter_1_0, '0', blocks_file_sink_0_0, '0']
- [low_pass_filter_1_0_0, '0', blocks_file_sink_0_0_0, '0']
- [low_pass_filter_1_0_0_0, '0', blocks_file_sink_0_0_0_0, '0']
- [low_pass_filter_1_0_0_1, '0', blocks_file_sink_0_0_0_1, '0']
- [low_pass_filter_1_0_0_2, '0', blocks_file_sink_0_0_0_2, '0']
- [low_pass_filter_1_0_0_3, '0', blocks_file_sink_0_0_0_3, '0']
- [low_pass_filter_1_0_0_4, '0', blocks_file_sink_0_0_0_4, '0']
- [low_pass_filter_1_0_0_5, '0', blocks_file_sink_0_0_0_5, '0']
- [low_pass_filter_1_0_0_6, '0', blocks_file_sink_0_0_0_6, '0']
- [low_pass_filter_1_0_0_6_0, '0', blocks_file_sink_0_0_0_6_0, '0']
- [low_pass_filter_1_0_0_7, '0', blocks_file_sink_0_0_0_7, '0']
- [low_pass_filter_1_0_0_7_0, '0', blocks_file_sink_0_0_0_7_0, '0']
- [low_pass_filter_1_0_0_8, '0', blocks_file_sink_0_0_0_8, '0']
- [low_pass_filter_1_0_0_8_0, '0', blocks_file_sink_0_0_0_8_0, '0']
- [low_pass_filter_1_0_1, '0', blocks_file_sink_0_0_1, '0']
- [low_pass_filter_1_0_2, '0', blocks_file_sink_0_0_2, '0']
- [low_pass_filter_1_0_3, '0', blocks_file_sink_0_0_3, '0']
- [low_pass_filter_1_0_4, '0', blocks_file_sink_0_0_4, '0']
- [low_pass_filter_1_0_5, '0', blocks_file_sink_0_0_5, '0']
- [low_pass_filter_1_0_6, '0', blocks_file_sink_0_0_6, '0']
- [low_pass_filter_1_0_7, '0', blocks_file_sink_0_0_7, '0']
- [low_pass_filter_1_0_7_0, '0', blocks_file_sink_0_0_7_0, '0']
- [low_pass_filter_1_0_8, '0', blocks_file_sink_0_0_8, '0']
- [low_pass_filter_1_0_8_0, '0', blocks_file_sink_0_0_8_0, '0']
- [low_pass_filter_1_0_9, '0', blocks_file_sink_0_0_9, '0']
- [low_pass_filter_1_0_9_0, '0', blocks_file_sink_0_0_9_0, '0']
- [virtual_source_0, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
