options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: lucy_ata
    output_language: python
    run_options: run
    title: Lucy decoder
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '60000'
  states: {}
- name: codeword_len
  id: variable
  parameters:
    value: '53544'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: pll_bw
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.92e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/(decim*baudrate)
  states: {}
- name: syncword
  id: variable
  parameters:
    value: '''766F0936B9E40863'''
  states: {}
- name: syncword_bits
  id: variable
  parameters:
    value: '''''.join([str(a) for a in np.unpackbits(np.frombuffer(bytes.fromhex(syncword), ''uint8''))])'
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: math.pi
    min_freq: '-math.pi'
    w: 2*math.pi*pll_bw/samp_rate
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: lucy_frames.u8
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/lucy/Lucy_2021-10-17T08:51:44.396540_0x
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/lucy/Lucy_2021-10-17T08:51:44.396540_0y
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: float
  states: {}
- name: blocks_tagged_stream_to_pdu_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: float
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: syncword_bits
    tagname: payload_start
    threshold: '8'
    type: float
  states: {}
- name: digital_correlate_access_code_tag_xx_0_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: syncword_bits
    tagname: payload_start
    threshold: '8'
    type: float
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.001'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.001'
    max_dev: '0.01'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: dslwp_ccsds_pseudo_randomizer_0
  id: dslwp_ccsds_pseudo_randomizer
  parameters:
    data_format: '3'
  states: {}
- name: dslwp_ccsds_turbo_decode_0
  id: dslwp_ccsds_turbo_decode
  parameters:
    base: '223'
    code_type: '6'
    iterations: '20'
    octets: '5'
    sigma: '0.5'
    update_sigma: '0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Auto-polarization
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Auto-polarization"""

          def __init__(self, fft_size=1024, fft_avg=1,
                           iir_weight = 1e-2): # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Auto-polarization',   # will show up in GRC
                  in_sig=[np.complex64]*2,
                  out_sig=[np.complex64]*2
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.fft_size = fft_size
              self.fft_avg = fft_avg
              self.set_output_multiple(fft_size * fft_avg)
              self.iir_weight = iir_weight
              self.noise_ampl = np.ones(2)
              self.sig_ampl = np.ones(2)
              self.phase = 0

          def work(self, input_items, output_items):
              x = np.array([inp.reshape((-1, self.fft_avg, self.fft_size))
                                for inp in input_items])
              # axes for x are:
              # (channel: 2, block, fft_num: fft_avg, fft_bin: fft_size)

              fx = np.fft.fft(x)
              fx_sq_avg = np.average(np.abs(fx)**2, axis = 2)
              noise_ampl = np.sqrt(np.median(fx_sq_avg, axis = 2))

              fx_sq_avg_ch_max = np.max(fx_sq_avg/noise_ampl[...,np.newaxis]**2, axis = 0)
              peak_idx = np.argmax(fx_sq_avg_ch_max, axis = 1)

              f_cross = np.average(fx[0] * np.conjugate(fx[1]), axis = 1)
              phase = np.angle(f_cross[np.arange(f_cross.shape[0]),
                                           peak_idx])
              sig_ampl = fx_sq_avg[:,np.arange(fx_sq_avg.shape[1]),peak_idx] #- noise_ampl
              sig_ampl = np.sqrt(np.clip(sig_ampl, 0, np.inf))

              # update IIR filters
              for j in range(x.shape[1]):
                  noise_ampl[:,j] = (1-self.iir_weight)*self.noise_ampl \
                    + self.iir_weight*noise_ampl[:,j]
                  self.noise_ampl = noise_ampl[:,j]
                  sig_ampl[:,j] = (1-self.iir_weight)*self.sig_ampl \
                    + self.iir_weight*sig_ampl[:,j]
                  self.sig_ampl = sig_ampl[:,j]
                  phase_diff = phase[j] - self.phase
                  phase_diff = (phase_diff + np.pi) % (2*np.pi) - np.pi
                  phase[j] = self.phase + self.iir_weight*phase_diff
                  self.phase = (phase[j] + np.pi) % (2*np.pi) - np.pi

              tau = np.log10(sig_ampl[0]/noise_ampl[0]+1e-6) \
                - np.log10(sig_ampl[1]/noise_ampl[1]+1e-6)
              tau = 20*tau/6*0.5 + 0.5
              tau = np.clip(tau, 0, 1)
              # note tau = 1 if sig[0] is 6dB stronger than sig[1] and
              # tau = 0 if sig[0] is 6dB weaker than sig[1]
              a_phase = (tau - 1) * phase
              b_phase = tau * phase
              # note -a_phase + b_phase = phase
              
              alpha = (np.exp(1j*a_phase) * sig_ampl[0] / noise_ampl[0])[:,np.newaxis]
              beta = (np.exp(1j*b_phase) * sig_ampl[1] / noise_ampl[1])[:,np.newaxis]

              y = x.reshape((x.shape[0], x.shape[1], self.fft_avg * self.fft_size))
              y = y / noise_ampl[...,np.newaxis] * np.sqrt(self.fft_size)
              output_items[0][:] = (alpha * y[0] + beta * y[1]).ravel()
              output_items[1][:] = (np.conjugate(beta) * y[0] - np.conjugate(alpha) * y[1]).ravel()
              return len(output_items[0])
    fft_avg: int(0.1*samp_rate/2048)
    fft_size: '2048'
    iir_weight: '0.1'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: int(sps)*[1/int(sps)]
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 281.25e3
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 100e3, 10e3)
    type: fcf
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '670'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, 1.92e6, 400e3, 25e3)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '670'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, 1.92e6, 400e3, 25e3)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    nconnections: '2'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate/decim
    fc: '0'
    fftsize: '4096'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    marker2: '0'
    size: '120000'
    srate: samp_rate
    style1: '0'
    style2: '0'
    type: complex
    ymax: '3'
    ymin: '-3'
  states: {state: disabled}
- name: satellites_fixedlen_tagger_0
  id: satellites_fixedlen_tagger
  parameters:
    minoutbuf: 2**16
    packet_len: codeword_len
    packetlen_tag: packet_len
    stream_type: float
    syncword_tag: payload_start
  states: {}
- name: satellites_fixedlen_tagger_0_0
  id: satellites_fixedlen_tagger
  parameters:
    minoutbuf: 2**16
    packet_len: codeword_len
    packetlen_tag: packet_len
    stream_type: float
    syncword_tag: payload_start
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-3'
    reference: '1.0'
  states: {}
- name: satellites_rms_agc_1
  id: satellites_rms_agc
  parameters:
    alpha: '1e-3'
    reference: '1.0'
  states: {}
- name: satellites_sx12xx_check_crc_0
  id: satellites_sx12xx_check_crc
  parameters:
    final: '0'
    initial: '0xFFFF'
  states: {}

connections:
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_float_0, '0']
- [blocks_complex_to_float_0, '0', blocks_null_sink_1, '0']
- [blocks_complex_to_float_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_freq_sink_x_0, '1']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_real_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', freq_xlating_fir_filter_xxx_1_0, '0']
- [blocks_multiply_const_vxx_0, '0', digital_correlate_access_code_tag_xx_0_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, dslwp_ccsds_pseudo_randomizer_0, in]
- [blocks_tagged_stream_to_pdu_0_0, pdus, dslwp_ccsds_pseudo_randomizer_0, in]
- [digital_correlate_access_code_tag_xx_0, '0', satellites_fixedlen_tagger_0, '0']
- [digital_correlate_access_code_tag_xx_0_0, '0', satellites_fixedlen_tagger_0_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [dslwp_ccsds_pseudo_randomizer_0, out, dslwp_ccsds_turbo_decode_0, in]
- [dslwp_ccsds_turbo_decode_0, out, satellites_sx12xx_check_crc_0, in]
- [epy_block_0, '0', satellites_rms_agc_0, '0']
- [epy_block_0, '1', blocks_null_sink_0, '0']
- [fir_filter_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', satellites_rms_agc_1, '0']
- [freq_xlating_fir_filter_xxx_1, '0', epy_block_0, '0']
- [freq_xlating_fir_filter_xxx_1_0, '0', epy_block_0, '1']
- [satellites_fixedlen_tagger_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [satellites_fixedlen_tagger_0_0, '0', blocks_tagged_stream_to_pdu_0_0, '0']
- [satellites_rms_agc_0, '0', analog_pll_carriertracking_cc_0, '0']
- [satellites_rms_agc_1, '0', fir_filter_xxx_0, '0']
- [satellites_sx12xx_check_crc_0, ok, blocks_pdu_to_tagged_stream_0, pdus]
- [satellites_sx12xx_check_crc_0, ok, satellites_hexdump_sink_0, in]

metadata:
  file_format: 1
