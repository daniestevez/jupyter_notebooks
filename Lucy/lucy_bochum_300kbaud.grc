options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: lucy_bochum_300kbaud
    output_language: python
    run_options: run
    title: Lucy decoder (300 kbaud)
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '300000'
  states: {}
- name: codeword_len
  id: variable
  parameters:
    value: '53544'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '1'
  states: {}
- name: pll_bw
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.25e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/(decim*baudrate)
  states: {}
- name: syncword
  id: variable
  parameters:
    value: '''766F0936B9E40863'''
  states: {}
- name: syncword_bits
  id: variable
  parameters:
    value: '''''.join([str(a) for a in np.unpackbits(np.frombuffer(bytes.fromhex(syncword), ''uint8''))])'
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: math.pi
    min_freq: '-math.pi'
    w: 2*math.pi*pll_bw/samp_rate
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: lucy_frames.u8
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/daniel/lucy/SDRSharp_20211024_214614Z_8445607013Hz_IQ.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: syncword_bits
    tagname: payload_start
    threshold: '10'
    type: float
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.001'
    max_dev: '0.01'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: dslwp_ccsds_pseudo_randomizer_0
  id: dslwp_ccsds_pseudo_randomizer
  parameters:
    data_format: '3'
  states: {}
- name: dslwp_ccsds_turbo_decode_0
  id: dslwp_ccsds_turbo_decode
  parameters:
    base: '223'
    code_type: '6'
    iterations: '20'
    octets: '5'
    sigma: '0.5'
    update_sigma: '0'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: int(sps)*[1.5/int(sps)]
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, 1.92e6, 500e3, 25e3)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate/decim
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '.3'
    marker1: '0'
    size: '120000'
    srate: samp_rate
    style1: '0'
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}
- name: satellites_fixedlen_tagger_0
  id: satellites_fixedlen_tagger
  parameters:
    minoutbuf: 2**16
    packet_len: codeword_len
    packetlen_tag: packet_len
    stream_type: float
    syncword_tag: payload_start
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-3'
    reference: '1.0'
  states: {}
- name: satellites_sx12xx_check_crc_0
  id: satellites_sx12xx_check_crc
  parameters:
    final: '0'
    initial: '0xFFFF'
  states: {}

connections:
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_float_0, '0']
- [blocks_complex_to_float_0, '0', blocks_null_sink_1, '0']
- [blocks_complex_to_float_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', fir_filter_xxx_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_freq_sink_x_0, '1']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, dslwp_ccsds_pseudo_randomizer_0, in]
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_2, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [digital_correlate_access_code_tag_xx_0, '0', satellites_fixedlen_tagger_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0, '0']
- [dslwp_ccsds_pseudo_randomizer_0, out, dslwp_ccsds_turbo_decode_0, in]
- [dslwp_ccsds_turbo_decode_0, out, satellites_sx12xx_check_crc_0, in]
- [fir_filter_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', satellites_rms_agc_0, '0']
- [satellites_fixedlen_tagger_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [satellites_rms_agc_0, '0', analog_pll_carriertracking_cc_0, '0']
- [satellites_sx12xx_check_crc_0, ok, blocks_pdu_to_tagged_stream_0, pdus]
- [satellites_sx12xx_check_crc_0, ok, satellites_hexdump_sink_0, in]

metadata:
  file_format: 1
