options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: crewdragon
    output_language: python
    title: Crew Dragon Demo-2 decoder
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: 2350000+40
  states: {}
- name: clk_bw
  id: variable_qtgui_entry
  parameters:
    label: Clock bandwidth
    type: real
    value: '0.01'
  states: {}
- name: fir_taps
  id: variable
  parameters:
    value: '[0.5]*2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 800e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/daniel/crewdragon2_symbols.f32
    type: float
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/daniel/crewdragon2_frames.u8
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: out.c64
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/Descargas/gqrx_20200531_031939_2215999999_4000000_fc.raw
    length: samp_rate
    offset: 40*samp_rate
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: clk_bw
    max_dev: '0.001'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '1.7'
    ted_gain: '1.47'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: fir_taps
    type: ccc
  states: {}
- name: fir_filter_xxx_1_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: fir_taps
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: 2216e6
    fftsize: '4096'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-50'
    ymin: '-80'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1000'
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    size: '10000'
    srate: baudrate
    style1: '0'
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: satellites_ccsds_rs_deframer_0
  id: satellites_ccsds_rs_deframer
  parameters:
    differential: 'False'
    dual_basis: 'True'
    frame_size: '214'
    threshold: '4'
  states: {state: disabled}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1.0'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_mag_squared_0, '0', blocks_sub_xx_0, '0']
- [blocks_complex_to_mag_squared_1, '0', blocks_sub_xx_0, '1']
- [blocks_file_source_0, '0', blocks_file_sink_2, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', satellites_rms_agc_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', fir_filter_xxx_1, '0']
- [blocks_multiply_xx_0, '0', fir_filter_xxx_1_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_file_sink_1, '0']
- [blocks_sub_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_file_sink_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_symbol_sync_xx_0, '0', satellites_ccsds_rs_deframer_0, '0']
- [fir_filter_xxx_1, '0', blocks_complex_to_mag_squared_0, '0']
- [fir_filter_xxx_1_0, '0', blocks_complex_to_mag_squared_1, '0']
- [satellites_ccsds_rs_deframer_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [satellites_rms_agc_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [satellites_rms_agc_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
